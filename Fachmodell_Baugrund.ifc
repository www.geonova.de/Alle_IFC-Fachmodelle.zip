Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 2

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Fachmodell_Baugrund.ifc.tmp
Time: 2026-09-15T21:58:26+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, DGGT Beispiel – Vorgabe DGGT
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, DGGT Beispiel – Vorgabe DGGT
Description: Projektstandort; LongName: DGGT Beispiel – Vorgabe DGGT

# IfcBorehole: BKF (10)
Pset_rbfSBL_Erkundung - Erkundungsart: BKF; Aufschlussunterkante: -6.96 m; Quelle: Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx; Kommentar: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.; Bemessungsgrundwasserstand: 18 m
Pset_Bohrungen_gemäß_DIN_EN_ISO_22475_1_2007_01 - Aufschlussbezeichnung: BKF; Ausführende Firma: Schmidt & Schmidt Geotechnik; Gerätetyp: Klemm 806-3G; Geräteführer: Schmidt; Anmerkungen: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.
Pset_rbfSBL_Wasserstände - Bemessungswasserstand: 18 m
Pset_rbfSBL_BoreholeStratigraphy - Intervall_01_Kenner: S1; Intervall_01_Name: Auffüllung; Intervall_01_Offen_am_Erkundungsende: no; Intervall_02_Kenner: S2; Intervall_02_Name: Sand/Kies; Intervall_02_Offen_am_Erkundungsende: no; Intervall_03_Offen_am_Erkundungsende: no; Intervall_04_Offen_am_Erkundungsende: no
Name | Description | Erkundung | Stützstelle | Rechtswert (m) = Rechtswert Aufschluss (m) | Hochwert (m) = Hochwert Aufschluss (m) | Ansatzhöhe (m) = Höhe Ansatzpunkt_Aufschluss (m) = Intervall_01_Oberkante (m) | Aufschlusstiefe (m) | Bohrwasserstand_mNN (m) = Bohrwasserstand (m) | Aufschlussnummer | Aufschlussdatum_von = Aufschlussdatum_bis | Intervall_01_Unterkante (m) = Intervall_02_Oberkante (m) | Intervall_01_Mächtigkeit (m) | Intervall_01_Quelle = Intervall_02_Quelle = Intervall_03_Quelle = Intervall_04_Quelle | Intervall_02_Unterkante (m) = Intervall_03_Oberkante (m) | Intervall_02_Mächtigkeit (m) | Intervall_03_Kenner | Intervall_03_Name | Intervall_03_Unterkante (m) = Intervall_04_Oberkante (m) | Intervall_03_Mächtigkeit (m) | Intervall_04_Kenner | Intervall_04_Name | Intervall_04_Unterkante (m) | Intervall_04_Mächtigkeit (m)
BKF 1 | Einzelne geotechnische Erkundung BKF 1 | BKF 1 | ST_BKF_1 | 0.4 | 29.4 | 23.04 | 30 | 17.64 | 1 | 01.02.2021 | 20.54 | 2.5 | BKF 1; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.04 | 10.5 | S3 | Lösslehm | 0.74 | 9.3 | S4 | Sand- und Schluffstein | -6.96 | 7.7
BKF 10 | Einzelne geotechnische Erkundung BKF 10 | BKF 10 | ST_BKF_10 | 2.6 | 1.5 | 23.7 | 30.66 | 18.3 | 10 | 12.02.2021 | 20.94 | 2.76 | BKF 10; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.54 | 11.4 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) | 6.94 | 2.6 | S3 | Lösslehm | -2.41 | 9.35 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_05_Kenner: S4; Intervall_05_Name: Sand- und Schluffstein; Intervall_05_Oberkante: -2.41 m; Intervall_05_Unterkante: -6.96 m; Intervall_05_Mächtigkeit: 4.55 m; Intervall_05_Offen_am_Erkundungsende: no; Intervall_05_Quelle: BKF 10; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx
BKF 3 | Einzelne geotechnische Erkundung BKF 3 | BKF 3 | ST_BKF_3 | 54.1 | 58.4 | 25.7 | 32.66 | 18.9 | 3 | 03.02.2021 | 20.84 | 4.86 | BKF 3; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.04 | 10.8 | S3 | Lösslehm | 0.94 | 9.1 | S4 | Sand- und Schluffstein | -6.96 | 7.9
BKF 4 | Einzelne geotechnische Erkundung BKF 4 | BKF 4 | ST_BKF_4 | 99.2 | 59.3 | 28.16 | 35.12 | 18.56 | 4 | 04.02.2021 | 19.54 | 8.62 | BKF 4; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 7.14 | 12.4 | S3 | Lösslehm | -3.16 | 10.3 | S4 | Sand- und Schluffstein | -6.96 | 3.8
BKF 5 | Einzelne geotechnische Erkundung BKF 5 | BKF 5 | ST_BKF_5 | 89.7 | 30.8 | 23.4 | 30.36 | 18 | 5 | 05.02.2021 | 20.64 | 2.76 | BKF 5; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 11.04 | 9.6 | S3 | Lösslehm | 0.19 | 10.85 | S4 | Sand- und Schluffstein | -6.96 | 7.15
BKF 6 | Einzelne geotechnische Erkundung BKF 6 | BKF 6 | ST_BKF_6 | 99 | 0.7 | 23.14 | 30.1 | 18.64 | 6 | 08.02.2021 | 21.24 | 1.9 | BKF 6; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 11.84 | 9.4 | S3 | Lösslehm | 1.14 | 10.7 | S4 | Sand- und Schluffstein | -6.96 | 8.1
BKF 7 | Einzelne geotechnische Erkundung BKF 7 | BKF 7 | ST_BKF_7 | 48.4 | 26.6 | 23.06 | 30.02 | 18.76 | 7 | 09.02.2021 | 19.64 | 3.42 | BKF 7; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.24 | 10.4 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) | 7.14 | 2.1 | S3 | Lösslehm | -0.36 | 7.5 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_05_Kenner: S4; Intervall_05_Name: Sand- und Schluffstein; Intervall_05_Oberkante: -0.36 m; Intervall_05_Unterkante: -6.96 m; Intervall_05_Mächtigkeit: 6.6 m; Intervall_05_Offen_am_Erkundungsende: no; Intervall_05_Quelle: BKF 7; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx
BKF 9 | Einzelne geotechnische Erkundung BKF 9 | BKF 9 | ST_BKF_9 | 25.4 | 15.8 | 23.08 | 30.04 | 17.98 | 9 | 11.02.2021 | 21.44 | 1.64 | BKF 9; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 11.24 | 10.2 | S3 | Lösslehm | 0.34 | 10.9 | S4 | Sand- und Schluffstein | -6.96 | 7.3
BKF/GW 2 | Einzelne geotechnische Erkundung BKF/GW 2 | BKF/GW 2 | ST_BKF_GW_2 | 8.9 | 58.6 | 22.94 | 29.9 | 18.04 | 2 | 02.02.2021 | 20.04 | 2.9 | BKF/GW 2; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.94 | 10.1 | S3 | Lösslehm | 1.24 | 8.7 | S4 | Sand- und Schluffstein | -6.96 | 8.2 | Pset_Bohrungen_gemäß_DIN_EN_ISO_22475_1_2007_01 - Zusatzbezeichnung: GW
BKF/GW 8 | Einzelne geotechnische Erkundung BKF/GW 8 | BKF/GW 8 | ST_BKF_GW_8 | 54.2 | 1.4 | 23.1 | 30.06 | 18.3 | 8 | 10.02.2021 | 20.84 | 2.26 | BKF/GW 8; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 7.44 | 13.4 | S3 | Lösslehm | -1.26 | 8.7 | S4 | Sand- und Schluffstein | -6.96 | 5.7 | Pset_Bohrungen_gemäß_DIN_EN_ISO_22475_1_2007_01 - Zusatzbezeichnung: GW

# IfcBorehole: CPT (5)
Pset_rbfSBL_Erkundung - Erkundungsart: CPT; Aufschlussunterkante: -6.96 m; Quelle: Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx; Kommentar: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.
Pset_Drucksondierung_gemäß_DIN_EN_ISO_22476_1_2013_10 - Aufschlussbezeichnung: CPT; Ausführende Firma: Schmidt & Schmidt Geotechnik; Typ der Drucksondierung: TE1; Anwendungsklasse: 2; Geräteführer: Schmidt; Anmerkungen: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.
Pset_rbfSBL_BoreholeStratigraphy - Intervall_01_Kenner: S1; Intervall_01_Name: Auffüllung; Intervall_01_Offen_am_Erkundungsende: no; Intervall_02_Kenner: S2; Intervall_02_Name: Sand/Kies; Intervall_02_Offen_am_Erkundungsende: no; Intervall_03_Kenner: S3; Intervall_03_Name: Lösslehm; Intervall_03_Offen_am_Erkundungsende: no; Intervall_04_Kenner: S4; Intervall_04_Name: Sand- und Schluffstein; Intervall_04_Unterkante: -6.96 m; Intervall_04_Offen_am_Erkundungsende: no
Name | Description | Erkundung | Stützstelle | Rechtswert (m) = Rechtswert Aufschluss (m) | Hochwert (m) = Hochwert Aufschluss (m) | Ansatzhöhe (m) = Höhe Ansatzpunkt_Aufschluss (m) = Intervall_01_Oberkante (m) | Aufschlusstiefe (m) | Aufschlussnummer | Aufschlussdatum_von = Aufschlussdatum_bis | Intervall_01_Unterkante (m) = Intervall_02_Oberkante (m) | Intervall_01_Mächtigkeit (m) | Intervall_01_Quelle = Intervall_02_Quelle = Intervall_03_Quelle = Intervall_04_Quelle | Intervall_02_Unterkante (m) = Intervall_03_Oberkante (m) | Intervall_02_Mächtigkeit (m) | Intervall_03_Unterkante (m) = Intervall_04_Oberkante (m) | Intervall_03_Mächtigkeit (m) | Intervall_04_Mächtigkeit (m)
CPT 1 | Einzelne geotechnische Erkundung CPT 1 | CPT 1 | ST_CPT_1 | 9.3 | 58.1 | 22.95 | 29.91 | 1 | 25.01.2021 | 19.94 | 3.01 | CPT 1; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.04 | 9.9 | 1.14 | 8.9 | 8.1
CPT 2 | Einzelne geotechnische Erkundung CPT 2 | CPT 2 | ST_CPT_2 | 55.1 | 58.3 | 25.9 | 32.86 | 2 | 26.01.2021 | 20.74 | 5.16 | CPT 2; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.14 | 10.6 | 0.74 | 9.4 | 7.7
CPT 3 | Einzelne geotechnische Erkundung CPT 3 | CPT 3 | ST_CPT_3 | 69.4 | 43.8 | 24.1 | 31.06 | 3 | 27.01.2021 | 20.44 | 3.66 | CPT 3; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.34 | 11.1 | -2.16 | 11.5 | 4.8
CPT 4 | Einzelne geotechnische Erkundung CPT 4 | CPT 4 | ST_CPT_4 | 77.8 | 15.3 | 23.12 | 30.08 | 4 | 28.01.2021 | 20.94 | 2.18 | CPT 4; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.94 | 11 | 1.34 | 8.6 | 8.3
CPT 5 | Einzelne geotechnische Erkundung CPT 5 | CPT 5 | ST_CPT_5 | 26.5 | 44.5 | 23.01 | 29.97 | 5 | 29.01.2021 | 20.74 | 2.27 | CPT 5; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.24 | 11.5 | -0.06 | 9.3 | 6.9

# IfcBuildingElementProxy: Homogeneous area (9)
Name | Description | Bezeichnung | Gewerk | Zugeordnete Baugrundschichten
Bohr 01 | Bohrarbeiten – Bohr 01 | Bohr 01 | Bohrarbeiten | S1; S2 | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Bezeichnung Bauleistung: Bohr; Nummer Bauleistung: 01; Homogenbereich: Bohr 01; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 15; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; A_Br_min: 250; A_Br_max: 750; A_Br: Vorschrift: NF P18-579:2013-02-09
Bohr 02 | Bohrarbeiten – Bohr 02 | Bohr 02 | Bohrarbeiten | G1; S3 | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Bezeichnung Bauleistung: Bohr; Nummer Bauleistung: 02; Homogenbereich: Bohr 02; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 5; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; A_Br_min: 100; A_Br_max: 300; A_Br: Vorschrift: NF P18-579:2013-02-09
Bohr 03 | Bohrarbeiten – Bohr 03 | Bohr 03 | Bohrarbeiten | S4 | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Bezeichnung Bauleistung: Bohr; Nummer Bauleistung: 03; Homogenbereich: Bohr 03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Erd 01 | Erdarbeiten – Erd 01 | Erd 01 | Erdarbeiten | S1 | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd; Nummer Bauleistung: 01; Homogenbereich: Erd 01; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 15; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05
Erd 02 | Erdarbeiten – Erd 02 | Erd 02 | Erdarbeiten | S2 | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd; Nummer Bauleistung: 02; Homogenbereich: Erd 02; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 10; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05
Erd 03 | Erdarbeiten – Erd 03 | Erd 03 | Erdarbeiten | G1; S3 | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd; Nummer Bauleistung: 03; Homogenbereich: Erd 03; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 5; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; Bodengruppe Erd-/Grundbau: UL, TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05
Erd 04 | Erdarbeiten – Erd 04 | Erd 04 | Erdarbeiten | S4 | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd; Nummer Bauleistung: 04; Homogenbereich: Erd 04; rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10
RRP 01 | Ramm-, Rüttel- und Pressarbeiten – RRP 01 | RRP 01 | Ramm-, Rüttel- und Pressarbeiten | S1; S2 | Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09 - Bezeichnung Bauleistung: RRP; Nummer Bauleistung: 01; Homogenbereich: RRP 01; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 15; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05
RRP 02 | Ramm-, Rüttel- und Pressarbeiten – RRP 02 | RRP 02 | Ramm-, Rüttel- und Pressarbeiten | G1; S3 | Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09 - Bezeichnung Bauleistung: RRP; Nummer Bauleistung: 02; Homogenbereich: RRP 02; Massenanteil Co/Bo/Lbo_min: 0; Massenanteil Co/Bo/Lbo_max: 5; Massenanteil Co/Bo/Lbo: Vorschrift: DIN EN ISO 17892-4:2017-04; Bodengruppe Erd-/Grundbau: UL, TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05

# IfcBuildingElementProxy: rbfSBL (6)
Pset_rbfSBL_Schnitt - Projektname: DGGT Beispiel – Vorgabe DGGT; Unterkante: -8.01841; Oberkante: 29.3788
Name | Schnittname | Schnittbezeichnung | Blickseite | Punktanzahl
Schnittflaeche_1-1 | Schnitt 1 | 1-1 | links | 2
Schnittflaeche_2-2 | Schnitt 2 | 2-2 | rechts | 2
Schnittflaeche_1 – Pfadschnitt-1 – Pfadschnitt | Schnitt 1 – Pfadschnitt | 1 – Pfadschnitt-1 – Pfadschnitt | links | 2
Schnittflaeche_2 – Pfadschnitt-2 – Pfadschnitt | Schnitt 2 – Pfadschnitt | 2 – Pfadschnitt-2 – Pfadschnitt | links | 2
Schnittflaeche_3-3 | Schnitt 3 | 3-3 | rechts | 2
Schnittflaeche_3 – Pfadschnitt-3 – Pfadschnitt | Schnitt 3 – Pfadschnitt | 3 – Pfadschnitt-3 – Pfadschnitt | links | 27

# IfcGeomodel: rbfSBL IfcGeomodel, DGGT Beispiel – Vorgabe DGGT – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_Allgemeine_Projektinformationen - Projektname: Testprojekt-Fachmodell_Baugrund; Modellautor: z. B. Jörg Bauer; Fachautor: z. B. Jörg Bauer; Datum der Erstellung: z. B. 24.06.2021; Datum der letzten Änderung: z. B. 07.07.2021; Entwicklungsstufe: Genehmigungsplanung; Koordinatensystem_Lage: Koordinatensystem_Lage: lokal; Lage_Status: ETRS89 / UTM zone 32N; Koordinatensystem_Höhe: DHHN2016; EPSG-Code_Koordinatensystem_Lage: -; EPSG-Code_Koordinatensystem_Höhe: 7837; Geotechnische Kategorie: GK3; Geotechnische Kategorie: Vorschrift: DIN 4020:2010-12; Erdbebenzone: 0; Erdbeben Baugrundklasse: C; Erdbeben Untergrundklasse: R; Erdbebengefährdung: Vorschrift: DIN EN 1998-1:2010-12 / DIN EN 1998-1/A1:2013-05; Höhensystem_Status: DHHN2016 / mNHN
Pset_rbfSBL_ProjectInformation - ProjectName: DGGT Beispiel; ProjectNumber: DGGT-Testprojekt-26-08-31-IFC-Varianten; Responsible: Geonova; Author: Geonova; Organization: Geonova; ModelAuthor: Geonova; DisciplineAuthor: Geonova; Description: DGGT-Testprojekt mit mehreren IFC-/Property-Set-Datensätzen für SVG/HTML und IFC4X3_ADD2.; ProjectPhase: Genehmigungsplanung; CreationDate: 2026-09-15; ModifiedDate: 2026-09-15; CoordinateReferenceSystem: lokal; ETRS89 / UTM zone 32N; EPSG-Code nicht angegeben; HeightReferenceSystem: DHHN2016 / mNHN / EPSG:7837; Notes: Projektphase: Genehmigungsplanung DGGT-Testprojekt: 15 einzelne BKF/CPT als IfcBorehole mit Erkundungsattributen und SVG-Zuordnung angereichert.

# IfcGeotechnicalStratum: Geotechnical stratum (68)
PredefinedType: SOLID
Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd
Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Bezeichnung Bauleistung: Bohr
Pset_rbfSBL_Geologie - Geometrieart: IfcTriangulatedFaceSet; GeschlosseneTeilkörper: 1; OffeneNetzkanten: 0; ReparierteTeilschalen: 0
Name | Description = Beschreibung | Erdarbeiten = Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Homogenbereich | Bohrarbeiten = Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Homogenbereich | Ramm-, Rüttel- und Pressarbeiten = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Homogenbereich | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Nummer Bauleistung | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Massenanteil Co/Bo/Lbo_min = Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Massenanteil Co/Bo/Lbo_min = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Massenanteil Co/Bo/Lbo_min | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Massenanteil Co/Bo/Lbo_max | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Massenanteil Co/Bo/Lbo: Vorschrift = Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Massenanteil Co/Bo/Lbo: Vorschrift = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Massenanteil Co/Bo/Lbo: Vorschrift | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Bodengruppe Erd-/Grundbau | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Bodengruppe Erd-/Grundbau: Vorschrift = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Bodengruppe Erd-/Grundbau: Vorschrift | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Nummer Bauleistung | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Massenanteil Co/Bo/Lbo_max = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Massenanteil Co/Bo/Lbo_max | A_Br_min | A_Br_max | A_Br: Vorschrift | Bezeichnung Bauleistung | Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Nummer Bauleistung | Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Bodengruppe Erd-/Grundbau | Einheitstyp | Kenner | DreieckeGrundriss | DreieckeGesamt | Netzknoten | TechnischeAbschlussknoten | DirektVernetzteLinsenkörper | Netzaufbau | IFCAbschlusstoleranz_m | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m) | Punktart | Punktname | Oberkante_m | Unterkante_m | Maechtigkeit_m
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | Schicht | S1 | 12190 | 25132 | 12568 | 0 | 0 | geschlossenes gemeinsames Netz | 0 | 18359.5 | 6000 | 1.48944 | 8.61814 | 3.05991 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m; Pset_rbfSBL_Geologie - Typkenner: S; Reihenfolge: 1; Obergrenze: OK_S1; Untergrenze: OK_S2; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: yes; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 0; RestkoerperIndex: 1; DurchZusatzkoerperErsetzt: yes
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | Schicht | S2 | 12190 | 25132 | 12568 | 0 | 0 | geschlossenes gemeinsames Netz | 0 | 65613.8 | 6000 | 9.36364 | 13.4054 | 10.9356 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_rbfSBL_Geologie - Typkenner: S; Reihenfolge: 2; Obergrenze: OK_S2; Untergrenze: OK_S3; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 2; RestkoerperIndex: 1; DurchZusatzkoerperErsetzt: yes; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | Schicht | S3 | 12190 | 25132 | 12568 | 0 | 0 | geschlossenes gemeinsames Netz | 0 | 58079.9 | 6000 | 7.49684 | 11.5308 | 9.67998 | Pset_rbfSBL_Geologie - Typkenner: S; Reihenfolge: 3; Obergrenze: OK_S3; Untergrenze: OK_S4; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 2; RestkoerperIndex: 1; DurchZusatzkoerperErsetzt: yes; Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | Schicht | S4 | 12190 | 25132 | 12568 | 0 | 0 | geschlossenes gemeinsames Netz | 0 | 40480.6 | 6000 | 3.79021 | 8.4154 | 6.74676 | Pset_rbfSBL_Geologie - Typkenner: S; Reihenfolge: 4; Obergrenze: OK_S4; Untergrenze: Modellunterkante (Darstellungsabschluss); Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: no; GrenzeinheitenBeschneidung: 0; RestkoerperIndex: 1; DurchZusatzkoerperErsetzt: yes; Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | Grenzlinse | G1 | 4960 | 10240 | 5122 | 160 | 1 | geschlossenes gemeinsames Netz | 0.000001 | 757.046 | 555.655 | 0.000001 | 2.1 | 1.36244 | Pset_rbfSBL_Geologie - Typkenner: GL; Instanz: 2; Entstehungsfolge: 5; ZulaessigeSchichten: S2, S3; Reichweite_m: 16.5; RangeLokal_m: 5; OffsetLokal_m: 0; OffsetLokalAktiv: yes; OffsetLokalGespeichert_m: 0; Endform: abgerundet; Grundrissform: elliptisch; WirksameGrundrissform: elliptisch; Mittelpunktmodus: Stützstelle; Linsenverteilung: ein Körper; Zufallsbereich: abgeleiteter Einflussbereich; Koerperrolle: Einzellinse; ZusaetzlicheZufallslinse: no; ZusaetzlicheLinsenAnzahl: 1; ZufallsbreiteMin_m: 1.98; ZufallsbreiteMax_m: 14.85; ZufallshoeheMin_m: 1.05; ZufallshoeheMax_m: 2.6; Koerperbreite_m: 33; MaximaleMaechtigkeit_m: 2.1; Pflichtvorkommen: yes; NullnachweisQuelle: no; TeilkörperIndex: 2; Stützstellenbindung: yes; Quellstützstelle: ST_BKF_7; Vorkommensindex: 1; Grundrissmittelpunkt: [48.4, 26.6]; AuskeilenderRand: yes; ÜberlagerungspunkteRaster: 0; BandueberschneidungenZulaessig: no; Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Schluff; Bodengruppe Erd-/Grundbau: UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 35; w_Boden_max: 54; w_Boden_mittel: 46.5; w_Boden: Anzahl Laborversuche: 4; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 4.2; I_P_max: 6.4; I_P_mittel: 4.5; I_P: Anzahl Laborversuche: 4; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 17.5; gamma_feucht_Boden_max: 19; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 10; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 20; phi_eff_min: 25; phi_eff_max: 27.5; E_S_Erstbel_min: 2 m; E_S_Erstbel_max: 4 m
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | Grenzlinse | G1 | 4960 | 10240 | 5122 | 49 | 1 | geschlossenes gemeinsames Netz | 0.000001 | 401.578 | 226.048 | 0.000001 | 2.6 | 1.77652 | Pset_rbfSBL_Geologie - Typkenner: GL; Instanz: 1; Entstehungsfolge: 5; ZulaessigeSchichten: S2, S3; Reichweite_m: 16.5; RangeLokal_m: 5; OffsetLokal_m: 0; OffsetLokalAktiv: yes; OffsetLokalGespeichert_m: 0; Endform: abgerundet; Grundrissform: elliptisch; WirksameGrundrissform: elliptisch; Mittelpunktmodus: Stützstelle; Linsenverteilung: ein Körper; Zufallsbereich: abgeleiteter Einflussbereich; Koerperrolle: Einzellinse; ZusaetzlicheZufallslinse: no; ZusaetzlicheLinsenAnzahl: 1; ZufallsbreiteMin_m: 1.98; ZufallsbreiteMax_m: 14.85; ZufallshoeheMin_m: 1.05; ZufallshoeheMax_m: 2.6; Koerperbreite_m: 33; MaximaleMaechtigkeit_m: 2.6; Pflichtvorkommen: yes; NullnachweisQuelle: no; TeilkörperIndex: 1; Stützstellenbindung: yes; Quellstützstelle: ST_BKF_10; Vorkommensindex: 1; Grundrissmittelpunkt: [2.6, 1.5]; AuskeilenderRand: yes; ÜberlagerungspunkteRaster: 0; BandueberschneidungenZulaessig: no; Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Schluff; Bodengruppe Erd-/Grundbau: UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 35; w_Boden_max: 54; w_Boden_mittel: 46.5; w_Boden: Anzahl Laborversuche: 4; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 4.2; I_P_max: 6.4; I_P_mittel: 4.5; I_P: Anzahl Laborversuche: 4; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 17.5; gamma_feucht_Boden_max: 19; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 10; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 20; phi_eff_min: 25; phi_eff_max: 27.5; E_S_Erstbel_min: 2 m; E_S_Erstbel_max: 4 m
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.9634 | 0.785398 | 2.49988 | 2.49988 | 2.49988 | Stützstelle | ST_BKF_1 | 23.0399 | 20.54 | 2.49988 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.24668 | 0.785398 | 10.5 | 10.5 | 10.5 | Stützstelle | ST_BKF_1 | 20.54 | 10.04 | 10.5 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.3042 | 0.785398 | 9.3 | 9.3 | 9.3 | Stützstelle | ST_BKF_1 | 10.04 | 0.74 | 9.3 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.04757 | 0.785398 | 7.7 | 7.7 | 7.7 | Stützstelle | ST_BKF_1 | 0.74 | -6.96 | 7.7 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.27298 | 0.785398 | 2.89405 | 2.89405 | 2.89405 | Stützstelle | ST_BKF_GW_2 | 22.934 | 20.04 | 2.89405 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.93252 | 0.785398 | 10.1 | 10.1 | 10.1 | Stützstelle | ST_BKF_GW_2 | 20.04 | 9.94 | 10.1 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.83296 | 0.785398 | 8.7 | 8.7 | 8.7 | Stützstelle | ST_BKF_GW_2 | 9.94 | 1.24 | 8.7 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.44026 | 0.785398 | 8.2 | 8.2 | 8.2 | Stützstelle | ST_BKF_GW_2 | 1.24 | -6.96 | 8.2 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 3.81704 | 0.785398 | 4.86 | 4.86 | 4.86 | Stützstelle | ST_BKF_3 | 25.7 | 20.84 | 4.86 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.4823 | 0.785398 | 10.8 | 10.8 | 10.8 | Stützstelle | ST_BKF_3 | 20.84 | 10.04 | 10.8 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.14712 | 0.785398 | 9.1 | 9.1 | 9.1 | Stützstelle | ST_BKF_3 | 10.04 | 0.94 | 9.1 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.20465 | 0.785398 | 7.9 | 7.9 | 7.9 | Stützstelle | ST_BKF_3 | 0.94 | -6.96 | 7.9 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.75292 | 0.785398 | 8.59809 | 8.59809 | 8.59809 | Stützstelle | ST_BKF_4 | 28.1381 | 19.54 | 8.59809 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 9.73894 | 0.785398 | 12.4 | 12.4 | 12.4 | Stützstelle | ST_BKF_4 | 19.54 | 7.14 | 12.4 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.0896 | 0.785398 | 10.3 | 10.3 | 10.3 | Stützstelle | ST_BKF_4 | 7.14 | -3.16 | 10.3 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.98451 | 0.785398 | 3.8 | 3.8 | 3.8 | Stützstelle | ST_BKF_4 | -3.16 | -6.96 | 3.8 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.1677 | 0.785398 | 2.76 | 2.76 | 2.76 | Stützstelle | ST_BKF_5 | 23.4 | 20.64 | 2.76 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.53982 | 0.785398 | 9.6 | 9.6 | 9.6 | Stützstelle | ST_BKF_5 | 20.64 | 11.04 | 9.6 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.52157 | 0.785398 | 10.85 | 10.85 | 10.85 | Stützstelle | ST_BKF_5 | 11.04 | 0.19 | 10.85 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 5.6156 | 0.785398 | 7.15 | 7.15 | 7.15 | Stützstelle | ST_BKF_5 | 0.19 | -6.96 | 7.15 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.49226 | 0.785398 | 1.9 | 1.9 | 1.9 | Stützstelle | ST_BKF_6 | 23.14 | 21.24 | 1.9 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.38274 | 0.785398 | 9.4 | 9.4 | 9.4 | Stützstelle | ST_BKF_6 | 21.24 | 11.84 | 9.4 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.40376 | 0.785398 | 10.7 | 10.7 | 10.7 | Stützstelle | ST_BKF_6 | 11.84 | 1.14 | 10.7 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.36173 | 0.785398 | 8.1 | 8.1 | 8.1 | Stützstelle | ST_BKF_6 | 1.14 | -6.96 | 8.1 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
