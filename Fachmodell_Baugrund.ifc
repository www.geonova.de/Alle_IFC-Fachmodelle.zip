Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 2

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Fachmodell_Baugrund.ifc.tmp
Time: 2026-10-03T13:17:19+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, Tunnel – V0
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, Tunnel – V0
Description: Projektstandort; LongName: Tunnel – V0

# IfcBorehole: BKF (42)
Pset_rbfSBL_Erkundung - Erkundungsart: BKF; Aufschlusstiefe: 28.5 m
Pset_rbfSBL_BoreholeStratigraphy - Intervall_01_Kenner: S1; Intervall_01_Name: Auffüllung – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen; Intervall_01_Offen_am_Erkundungsende: no; Intervall_02_Kenner: S2; Intervall_02_Name: Sand/Kies – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen; Intervall_02_Offen_am_Erkundungsende: no; Intervall_03_Offen_am_Erkundungsende: no; Intervall_04_Offen_am_Erkundungsende: no; Intervall_05_Offen_am_Erkundungsende: no
Name | Description | Erkundung | Stützstelle | Rechtswert (m) | Hochwert (m) | Ansatzhöhe (m) = Intervall_01_Oberkante (m) | Aufschlussunterkante (m) | Quelle = Intervall_01_Quelle = Intervall_02_Quelle = Intervall_03_Quelle = Intervall_04_Quelle = Intervall_05_Quelle | Kommentar | Intervall_01_Unterkante (m) = Intervall_02_Oberkante (m) | Intervall_01_Mächtigkeit (m) | Intervall_02_Unterkante (m) = Intervall_03_Oberkante (m) | Intervall_02_Mächtigkeit (m) | Intervall_03_Kenner | Intervall_03_Name | Intervall_03_Unterkante (m) = Intervall_04_Oberkante (m) | Intervall_03_Mächtigkeit (m) | Intervall_04_Kenner | Intervall_04_Name | Intervall_04_Unterkante (m) = Intervall_05_Oberkante (m) | Intervall_04_Mächtigkeit (m) | Intervall_05_Kenner | Intervall_05_Name | Intervall_05_Unterkante (m) | Intervall_05_Mächtigkeit (m)
FIK_BV_KanalNord_BKF_01 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_BV_KanalNord_BKF_01; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_BV_KanalNord_BKF_01 | TUN_BV_KN_01 | 192.725 | 81.366 | 24.764 | -3.736 | FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV KanalNord; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_4 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 205.000 m, Querabstand +34.000 m. | 20.223 | 4.541 | 13.691 | 6.532 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.266 | 5.426 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.264 | 2.002 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.736 | 10
FIK_BV_KanalNord_BKF_02 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_BV_KanalNord_BKF_02; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_BV_KanalNord_BKF_02 | TUN_BV_KN_02 | 477.292 | 37.079 | 23.513 | -4.987 | FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV KanalNord; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_GW_8 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 485.000 m, Querabstand -39.000 m. | 22.122 | 1.391 | 13.875 | 8.247 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.521 | 5.354 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 5.013 | 3.508 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -4.987 | 10
FIK_BV_KanalNord_BKF_03 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_BV_KanalNord_BKF_03; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_BV_KanalNord_BKF_03 | TUN_BV_KN_03 | 760.459 | 105.936 | 23.13 | -5.37 | FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV KanalNord; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_6 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 765.000 m, Querabstand +46.000 m. | 21.962 | 1.168 | 16.185 | 5.777 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.608 | 6.576 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.63 | 4.978 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.37 | 10
FIK_BV_Parkhaus_BKF_04 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_BV_Parkhaus_BKF_04; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_BV_Parkhaus_BKF_04 | TUN_BV_PH_04 | 1037.69 | -2.449 | 25.38 | -3.12 | FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV Parkhaus; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1045.000 m, Querabstand -52.000 m. | 23.272 | 2.108 | 16.863 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 15.569 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.947 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.88 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.88 m; Intervall_06_Unterkante: -3.12 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV Parkhaus; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_BV_Parkhaus_BKF_05 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_BV_Parkhaus_BKF_05; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_BV_Parkhaus_BKF_05 | TUN_BV_PH_05 | 1312.97 | 105.198 | 24.703 | -3.797 | FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV Parkhaus; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1325.000 m, Querabstand +38.000 m. | 22.595 | 2.108 | 16.186 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 14.892 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.27 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.203 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.203 m; Intervall_06_Unterkante: -3.797 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV Parkhaus; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_BV_Parkhaus_BKF_06 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_BV_Parkhaus_BKF_06; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_BV_Parkhaus_BKF_06 | TUN_BV_PH_06 | 1650.39 | 24.305 | 23.392 | -5.108 | FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV Parkhaus; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1665.000 m, Querabstand -44.000 m. | 21.284 | 2.108 | 14.875 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 13.581 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.959 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.892 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 4.892 m; Intervall_06_Unterkante: -5.108 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; fiktives Nachbar-BV Parkhaus; außerhalb des 40-m-Modellstreifens. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_TUN_BKF_001 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_001; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_001 | TUN_ST_001 | -3.705 | 14.104 | 24 | -4.5 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_4 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 0.000 m, Querabstand +14.582 m. | 19.459 | 4.541 | 12.927 | 6.532 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 7.502 | 5.426 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 5.5 | 2.002 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -4.5 | 10
FIK_TUN_BKF_003 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_003; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_003 | TUN_ST_003 | 82.798 | 11.312 | 25.154 | -3.346 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_4 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 83.074 m, Querabstand -9.819 m. | 20.614 | 4.541 | 14.082 | 6.532 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.656 | 5.426 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.654 | 2.002 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.346 | 10
FIK_TUN_BKF_006 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_006; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_006 | TUN_ST_006 | 185.803 | 32.963 | 24.846 | -3.654 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 188.762 m, Querabstand -12.045 m. | 22.738 | 2.108 | 16.329 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 15.035 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.413 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.346 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.346 m; Intervall_06_Unterkante: -3.654 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_TUN_BKF_007 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_007; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_007 | TUN_ST_007 | 238.729 | 47.78 | 24.703 | -3.797 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 243.869 m, Querabstand -7.478 m. | 23.021 | 1.682 | 17.171 | 5.85 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.56 | 6.611 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.203 | 4.357 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.797 | 10 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV2; Intervall_06_Name: Tonstein V2, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: 5.203 m; Intervall_06_Unterkante: 3.703 m; Intervall_06_Mächtigkeit: 1.5 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_5 nur als geologische Vorlage.
FIK_TUN_BKF_008 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_008; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_008 | TUN_ST_008 | 267.972 | 72.176 | 24.81 | -3.69 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_9 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 276.643 m, Querabstand +11.873 m. | 23.8 | 1.01 | 17.518 | 6.282 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.806 | 6.713 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.31 | 4.496 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.69 | 10
FIK_TUN_BKF_009 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_009; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_009 | TUN_ST_009 | 306.872 | 53.269 | 25.008 | -3.492 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 312.492 m, Querabstand -12.213 m. | 23.343 | 1.665 | 16.464 | 6.879 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 14.895 | 1.569 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.254 | 5.642 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.508 | 2.745 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.508 m; Intervall_06_Unterkante: -3.492 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage.
FIK_TUN_BKF_011 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_011; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_011 | TUN_ST_011 | 388.472 | 73.11 | 24.934 | -3.566 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_GW_8 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 396.023 m, Querabstand -0.177 m. | 23.543 | 1.391 | 15.296 | 8.247 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.942 | 5.354 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.434 | 3.508 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.566 | 10
FIK_TUN_BKF_013 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_013; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_013 | TUN_ST_013 | 466.317 | 88.764 | 23.708 | -4.792 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_9 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 474.076 m, Querabstand +12.738 m. | 22.698 | 1.01 | 16.416 | 6.282 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.703 | 6.713 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 5.208 | 4.496 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -4.792 | 10
FIK_TUN_BKF_014 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_014; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_014 | TUN_ST_014 | 521.559 | 68.531 | 22.886 | -5.614 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_GW_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 529.367 m, Querabstand -6.986 m. | 21.092 | 1.794 | 14.843 | 6.249 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.46 | 5.383 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.386 | 5.074 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.614 | 10
FIK_TUN_BKF_015 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_015; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_015 | TUN_ST_015 | 550.752 | 85.589 | 22.703 | -5.797 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_4 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 557.994 m, Querabstand +11.010 m. | 18.162 | 4.541 | 11.63 | 6.532 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.205 | 5.426 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.203 | 2.002 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.797 | 10
FIK_TUN_BKF_016 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_016; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_016 | TUN_ST_016 | 581.237 | 72.077 | 22.716 | -5.784 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 588.971 m, Querabstand -1.033 m. | 21.034 | 1.682 | 15.184 | 5.85 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.573 | 6.611 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.216 | 4.357 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.784 | 10
FIK_TUN_BKF_017 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_017; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_017 | TUN_ST_017 | 625.367 | 84.972 | 22.975 | -5.525 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_9 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 632.140 m, Querabstand +14.552 m. | 21.965 | 1.01 | 15.684 | 6.282 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.971 | 6.713 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.475 | 4.496 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.525 | 10
FIK_TUN_BKF_020 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_020; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_020 | TUN_ST_020 | 742.512 | 52.665 | 23.197 | -5.303 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_4 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 751.324 m, Querabstand -8.535 m. | 18.656 | 4.541 | 12.125 | 6.532 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.699 | 5.426 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.697 | 2.002 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.303 | 10 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV2; Intervall_06_Name: Tonstein V2, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: 3.697 m; Intervall_06_Unterkante: 2.197 m; Intervall_06_Mächtigkeit: 1.5 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_4 nur als geologische Vorlage.
FIK_TUN_BKF_021 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_021; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_021 | TUN_ST_021 | 793.735 | 63.901 | 22.982 | -5.518 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 801.531 m, Querabstand +6.651 m. | 20.875 | 2.108 | 14.466 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 13.172 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.55 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.482 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 4.482 m; Intervall_06_Unterkante: -5.518 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_TUN_BKF_022 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_022; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_022 | TUN_ST_022 | 825.685 | 42.417 | 23.005 | -5.495 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 834.885 m, Querabstand -12.549 m. | 21.339 | 1.665 | 14.461 | 6.879 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 12.892 | 1.569 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 7.25 | 5.642 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.505 | 2.745 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 4.505 m; Intervall_06_Unterkante: -5.495 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage.
FIK_TUN_BKF_024 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_024; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_024 | TUN_ST_024 | 905.734 | 37.316 | 23.971 | -4.529 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 914.741 m, Querabstand -13.416 m. | 21.218 | 2.753 | 15.101 | 6.118 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.946 | 5.155 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 5.471 | 4.475 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -4.529 | 10
FIK_TUN_BKF_026 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_026; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_026 | TUN_ST_026 | 987.281 | 36.569 | 25.23 | -3.27 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 995.832 m, Querabstand -12.503 m. | 23.123 | 2.108 | 16.714 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 15.42 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.798 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.73 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.73 m; Intervall_06_Unterkante: -3.27 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_TUN_BKF_027 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_027; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_027 | TUN_ST_027 | 1032.96 | 57.156 | 25.387 | -3.113 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1041.629 m, Querabstand +7.698 m. | 23.706 | 1.682 | 17.856 | 5.85 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 11.244 | 6.611 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.887 | 4.357 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.113 | 10
FIK_TUN_BKF_028 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_028; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_028 | TUN_ST_028 | 1068.14 | 39.422 | 25.219 | -3.281 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1076.299 m, Querabstand -10.979 m. | 23.111 | 2.108 | 16.702 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 15.408 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.786 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.719 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.719 m; Intervall_06_Unterkante: -3.281 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.; Intervall_07_Kenner: TV4; Intervall_07_Name: Tonstein V4, fiktive interne Linse in Tonstein V3; Intervall_07_Oberkante: 0.719 m; Intervall_07_Unterkante: -1.281 m; Intervall_07_Mächtigkeit: 2 m; Intervall_07_Offen_am_Erkundungsende: no; Intervall_07_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.
FIK_TUN_BKF_029 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_029; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_029 | TUN_ST_029 | 1101.45 | 44.339 | 24.954 | -3.546 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_4 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1109.630 m, Querabstand -7.441 m. | 20.413 | 4.541 | 13.881 | 6.532 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 8.455 | 5.426 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.454 | 2.002 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.546 | 10
FIK_TUN_BKF_030 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_030; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_030 | TUN_ST_030 | 1152.98 | 52.146 | 24.662 | -3.838 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_1 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1161.432 m, Querabstand -2.551 m. | 23.12 | 1.542 | 16.645 | 6.475 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.91 | 5.735 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.162 | 4.748 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.838 | 10
FIK_TUN_BKF_031 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_031; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_031 | TUN_ST_031 | 1189.09 | 67.385 | 24.673 | -3.827 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_GW_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1198.530 m, Querabstand +10.139 m. | 22.879 | 1.794 | 16.629 | 6.249 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 11.246 | 5.383 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.173 | 5.074 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.827 | 10
FIK_TUN_BKF_032 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_032; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_032 | TUN_ST_032 | 1228.46 | 51.97 | 24.82 | -3.68 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_GW_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1236.637 m, Querabstand -8.264 m. | 23.025 | 1.794 | 16.776 | 6.249 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 11.393 | 5.383 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.32 | 5.074 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.68 | 10
FIK_TUN_BKF_033 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_033; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_033 | TUN_ST_033 | 1278.8 | 54.563 | 24.918 | -3.582 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_1 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1286.994 m, Querabstand -9.752 m. | 23.377 | 1.542 | 16.902 | 6.475 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 11.167 | 5.735 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.418 | 4.748 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -3.582 | 10
FIK_TUN_BKF_035 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_035; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_035 | TUN_ST_035 | 1345.5 | 67.916 | 24.327 | -4.173 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1354.573 m, Querabstand -1.613 m. | 21.574 | 2.753 | 15.457 | 6.118 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.302 | 5.155 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 5.827 | 4.475 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -4.173 | 10
FIK_TUN_BKF_037 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_037; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_037 | TUN_ST_037 | 1427.71 | 64.229 | 22.945 | -5.555 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_GW_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1436.584 m, Querabstand -10.138 m. | 21.15 | 1.794 | 14.901 | 6.249 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.518 | 5.383 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.445 | 5.074 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.555 | 10
FIK_TUN_BKF_039 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_039; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_039 | TUN_ST_039 | 1507.09 | 62.109 | 22.584 | -5.916 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_GW_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1516.420 m, Querabstand -13.973 m. | 20.79 | 1.794 | 14.541 | 6.249 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.158 | 5.383 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.084 | 5.074 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.916 | 10
FIK_TUN_BKF_040 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_040; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_040 | TUN_ST_040 | 1557.57 | 78.586 | 22.969 | -5.531 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_6 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1566.809 m, Querabstand +3.464 m. | 21.801 | 1.168 | 16.024 | 5.777 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.447 | 6.576 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.469 | 4.978 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.531 | 10 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV4; Intervall_06_Name: Tonstein V4, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: -1.531 m; Intervall_06_Unterkante: -3.531 m; Intervall_06_Mächtigkeit: 2 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_6 nur als geologische Vorlage.
FIK_TUN_BKF_041 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_041; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_041 | TUN_ST_041 | 1595.08 | 63.2 | 23.276 | -5.224 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1605.186 m, Querabstand -10.027 m. | 21.611 | 1.665 | 14.732 | 6.879 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 13.163 | 1.569 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 7.522 | 5.642 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.776 | 2.745 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 4.776 m; Intervall_06_Unterkante: -5.224 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage.
FIK_TUN_BKF_042 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_042; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_042 | TUN_ST_042 | 1634.17 | 77.999 | 23.408 | -5.092 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1642.956 m, Querabstand +7.782 m. | 20.655 | 2.753 | 14.538 | 6.118 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.383 | 5.155 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.908 | 4.475 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.092 | 10
FIK_TUN_BKF_043 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_043; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_043 | TUN_ST_043 | 1663.67 | 59.663 | 23.369 | -5.131 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1674.219 m, Querabstand -7.371 m. | 21.703 | 1.665 | 14.825 | 6.879 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 13.256 | 1.569 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 7.614 | 5.642 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.869 | 2.745 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 4.869 m; Intervall_06_Unterkante: -5.131 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage.
FIK_TUN_BKF_044 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_044; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_044 | TUN_ST_044 | 1719.92 | 71.264 | 23.197 | -5.303 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_6 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1728.319 m, Querabstand +11.731 m. | 22.029 | 1.168 | 16.251 | 5.777 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.675 | 6.576 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.697 | 4.978 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.303 | 10
FIK_TUN_BKF_045 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_045; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_045 | TUN_ST_045 | 1735.85 | 43.863 | 23.192 | -5.308 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1748.478 m, Querabstand -12.756 m. | 21.526 | 1.665 | 14.648 | 6.879 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 13.079 | 1.569 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 7.437 | 5.642 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.692 | 2.745 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 4.692 m; Intervall_06_Unterkante: -5.308 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_10 nur als geologische Vorlage.
FIK_TUN_BKF_046 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_046; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_046 | TUN_ST_046 | 1776.71 | 42.458 | 23.414 | -5.086 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_6 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1789.161 m, Querabstand -6.792 m. | 22.246 | 1.168 | 16.469 | 5.777 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 9.892 | 6.576 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 4.914 | 4.978 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -5.086 | 10
FIK_TUN_BKF_047 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_047; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_047 | TUN_ST_047 | 1825.13 | 46.074 | 24.062 | -4.438 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1835.846 m, Querabstand +6.629 m. | 21.309 | 2.753 | 15.192 | 6.118 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.037 | 5.155 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 5.562 | 4.475 | S5 | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | -4.438 | 10 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV2; Intervall_06_Name: Tonstein V2, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: 4.562 m; Intervall_06_Unterkante: 3.062 m; Intervall_06_Mächtigkeit: 1.5 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_3 nur als geologische Vorlage.
FIK_TUN_BKF_049 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_BKF_049; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_BKF_049 | TUN_ST_049 | 1909.21 | 31.048 | 25.368 | -3.132 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1920.814 m, Querabstand +11.515 m. | 23.26 | 2.108 | 16.851 | 6.409 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 15.557 | 1.294 | S3 | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 10.935 | 4.622 | S4 | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | 6.868 | 4.067 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: S5; Intervall_06_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_06_Oberkante: 6.868 m; Intervall_06_Unterkante: -3.132 m; Intervall_06_Mächtigkeit: 10 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_BKF_7 nur als geologische Vorlage.

# IfcBorehole: CPT (15)
Pset_rbfSBL_Erkundung - Erkundungsart: CPT; Aufschlusstiefe: 28.5 m
Pset_rbfSBL_BoreholeStratigraphy - Intervall_01_Kenner: S1; Intervall_01_Name: Auffüllung – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen; Intervall_01_Offen_am_Erkundungsende: no; Intervall_02_Kenner: S2; Intervall_02_Name: Sand/Kies – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen; Intervall_02_Offen_am_Erkundungsende: no; Intervall_03_Kenner: S3; Intervall_03_Name: Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen; Intervall_03_Offen_am_Erkundungsende: no; Intervall_04_Kenner: S4; Intervall_04_Name: Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen; Intervall_04_Offen_am_Erkundungsende: no; Intervall_05_Kenner: S5; Intervall_05_Name: Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen; Intervall_05_Mächtigkeit: 10 m; Intervall_05_Offen_am_Erkundungsende: no
Name | Description | Erkundung | Stützstelle | Rechtswert (m) | Hochwert (m) | Ansatzhöhe (m) = Intervall_01_Oberkante (m) | Aufschlussunterkante (m) = Intervall_05_Unterkante (m) | Quelle = Intervall_01_Quelle = Intervall_02_Quelle = Intervall_03_Quelle = Intervall_04_Quelle = Intervall_05_Quelle | Kommentar | Intervall_01_Unterkante (m) = Intervall_02_Oberkante (m) | Intervall_01_Mächtigkeit (m) | Intervall_02_Unterkante (m) = Intervall_03_Oberkante (m) | Intervall_02_Mächtigkeit (m) | Intervall_03_Unterkante (m) = Intervall_04_Oberkante (m) | Intervall_03_Mächtigkeit (m) | Intervall_04_Unterkante (m) = Intervall_05_Oberkante (m) | Intervall_04_Mächtigkeit (m)
FIK_TUN_CPT_002 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_002; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_002 | TUN_ST_002 | 40.917 | 23.118 | 24.772 | -3.728 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 45.404 m, Querabstand +12.007 m. | 21.867 | 2.905 | 15.899 | 5.968 | 10.607 | 5.292 | 6.272 | 4.335
FIK_TUN_CPT_004 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_004; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_004 | TUN_ST_004 | 123.122 | 37.453 | 25.194 | -3.306 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_1 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 128.456 m, Querabstand +5.993 m. | 23.332 | 1.862 | 17.209 | 6.123 | 11.704 | 5.505 | 6.694 | 5.01
FIK_TUN_CPT_005 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_005; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_005 | TUN_ST_005 | 150.921 | 26.1 | 25.072 | -3.428 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 152.993 m, Querabstand -11.341 m. | 22.892 | 2.18 | 16.281 | 6.611 | 9.431 | 6.85 | 6.572 | 2.859
FIK_TUN_CPT_010 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_010; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_010 | TUN_ST_010 | 353.563 | 57.204 | 25.13 | -3.37 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 359.711 m, Querabstand -13.376 m. | 22.95 | 2.18 | 16.339 | 6.611 | 9.489 | 6.85 | 6.63 | 2.859
FIK_TUN_CPT_012 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_012; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_012 | TUN_ST_012 | 436.49 | 86.778 | 24.25 | -4.25 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 444.381 m, Querabstand +11.287 m. | 21.345 | 2.905 | 15.377 | 5.968 | 10.085 | 5.292 | 5.75 | 4.335 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV4; Intervall_06_Name: Tonstein V4, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: -0.25 m; Intervall_06_Unterkante: -2.25 m; Intervall_06_Mächtigkeit: 2 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_2 nur als geologische Vorlage.
FIK_TUN_CPT_018 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_018; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_018 | TUN_ST_018 | 663.432 | 78.451 | 23.227 | -5.273 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 670.463 m, Querabstand +10.824 m. | 21.826 | 1.401 | 14.727 | 7.099 | 8.987 | 5.741 | 4.727 | 4.259
FIK_TUN_CPT_019 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_019; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_019 | TUN_ST_019 | 714.645 | 71.308 | 23.304 | -5.196 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 722.037 m, Querabstand +7.785 m. | 21.902 | 1.401 | 14.804 | 7.099 | 9.063 | 5.741 | 4.804 | 4.259
FIK_TUN_CPT_023 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_023; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_023 | TUN_ST_023 | 869.903 | 54.94 | 23.384 | -5.116 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 878.196 m, Querabstand +2.579 m. | 21.983 | 1.401 | 14.884 | 7.099 | 9.144 | 5.741 | 4.884 | 4.259
FIK_TUN_CPT_025 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_025; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_025 | TUN_ST_025 | 954.664 | 43.515 | 24.825 | -3.675 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 963.236 m, Querabstand -5.863 m. | 21.92 | 2.905 | 15.952 | 5.968 | 10.66 | 5.292 | 6.325 | 4.335
FIK_TUN_CPT_034 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_034; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_034 | TUN_ST_034 | 1315.8 | 68.297 | 24.703 | -3.797 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1324.982 m, Querabstand +0.991 m. | 23.302 | 1.401 | 16.203 | 7.099 | 10.462 | 5.741 | 6.203 | 4.259 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV2; Intervall_06_Name: Tonstein V2, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: 5.203 m; Intervall_06_Unterkante: 3.703 m; Intervall_06_Mächtigkeit: 1.5 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage.
FIK_TUN_CPT_036 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_036; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_036 | TUN_ST_036 | 1391.09 | 88.355 | 23.517 | -4.983 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1401.245 m, Querabstand +15.801 m. | 22.115 | 1.401 | 15.017 | 7.099 | 9.276 | 5.741 | 5.017 | 4.259
FIK_TUN_CPT_038 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_038; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_038 | TUN_ST_038 | 1463.4 | 90.448 | 22.591 | -5.909 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1473.143 m, Querabstand +14.874 m. | 20.411 | 2.18 | 13.799 | 6.611 | 6.95 | 6.85 | 4.091 | 2.859
FIK_TUN_CPT_048 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_048; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_048 | TUN_ST_048 | 1864.3 | 39.601 | 24.755 | -3.745 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_5 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1875.337 m, Querabstand +9.098 m. | 23.354 | 1.401 | 16.255 | 7.099 | 10.515 | 5.741 | 6.255 | 4.259
FIK_TUN_CPT_050 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_050; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_050 | TUN_ST_050 | 1954.66 | 17.654 | 25.513 | -2.987 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_2 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 1968.106 m, Querabstand +9.888 m. | 22.608 | 2.905 | 16.641 | 5.968 | 11.348 | 5.292 | 7.013 | 4.335 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_06_Kenner: TV4; Intervall_06_Name: Tonstein V4, fiktive interne Linse in Tonstein V3; Intervall_06_Oberkante: 1.013 m; Intervall_06_Unterkante: -0.987 m; Intervall_06_Mächtigkeit: 2 m; Intervall_06_Offen_am_Erkundungsende: no; Intervall_06_Quelle: FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_2 nur als geologische Vorlage.
FIK_TUN_CPT_051 | FIKTIV / synthetischer Bohrdatenbankaufschluss FIK_TUN_CPT_051; kein realer Ortsaufschluss und keine Bemessungsgrundlage. | FIK_TUN_CPT_051 | TUN_ST_051 | 1986.76 | 14.302 | 25.331 | -3.169 | FIKTIV / synthetische Projektdaten; Tunneltrasse. DGGT-Profil ST_CPT_3 nur als geologische Vorlage. | FIKTIV; kein realer Bohrdatenbankeintrag. Station 2000.000 m, Querabstand +14.787 m. | 23.151 | 2.18 | 16.54 | 6.611 | 9.69 | 6.85 | 6.831 | 2.859

# IfcBuildingElementProxy: Fiktiver Roehrenraum (2)
Description: Fiktiver Roehrenraum des Streckenbauwerks; geschlossener geometrischer Volumenkoerper, keine Auskleidung und keine Betonwand. Echte Modellhoehen ohne Darstellungsueberhoehung. Flaechenfarben zeigen den angetroffenen Baugrund abgedunkelt.; PredefinedType: USERDEFINED
Pset_rbfSBL_Korridorroehre - Strecke: Tunnel – Querschnitt; Modellvariante: V0; Bedeutung: Fiktiver Roehrenraum; keine Auskleidung / Betonwand; Achsenbezug: Tiefe unter lokaler GOK; Stationsmetrierung entlang Streckenmittellinie; Station_von_m: 23200; Station_bis_m: 25200; Durchmesser_Strecke_m: 7; Durchmesser_Bahnhof_m: 10; Achstiefe_Strecke_unter_GOK_m: 20; Achstiefe_Bahnhof_unter_GOK_m: 10; Achsenabstand_Strecke_m: 12; Achsenabstand_Bahnhof_m: 20; Bahnhofmitte_ab_Streckenbeginn_m: 500; Bahnhoflaenge_m: 100; Uebergangslaenge_m: 250; Vertikale_Ueberhoehung: 1; Netzlaengsschritt_max_m: 2; Ringsegmente: 32; Achsstationen: 1001; Geschlossen: yes; Offene_Netzkanten: 0; Farben: Baugrund je Dreieck; abgedunkelt; IfcIndexedColourMap; Abdunklungsfaktor: 0.7; Materialkennungen: S2, S3, S4, S5, TV2, TV4
Name | Komponentenkennung | Roehre | Achslaenge_3D_m = Length (m) | Volumen_m3 = GrossVolume
Roehre 1 - Tunnel – Querschnitt | corridor:tube:1 | 1 | 1996.77 | 89770.8
Roehre 2 - Tunnel – Querschnitt | corridor:tube:2 | 2 | 2004.45 | 90201.9

# IfcGeomodel: rbfSBL IfcGeomodel, Tunnel – V0 – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_rbfSBL_ProjectInformation - ProjectName: Tunnel; Description: Fiktive Übertragung aus DGGT-Beispiel; kein Ortsaufschluss und keine Bemessungsgrundlage.; Status: Fiktives Testprojekt; CreationDate: 2026-09-30; ModifiedDate: 2026-10-03; CoordinateReferenceSystem: lokales fiktives XY [m]; HeightReferenceSystem: lokales synthetisches Höhensystem [m]

# IfcGeotechnicalStratum: Geotechnical stratum (27)
PredefinedType: SOLID
Pset_rbfSBL_Geologie - GemeinsameMaterialpartition: yes; Geometrieart: IfcTriangulatedFaceSet; GeschlosseneTeilkörper: 1; DreieckeGrundriss: 0; OffeneNetzkanten: 0; TechnischeAbschlussknoten: 0; DirektVernetzteLinsenkörper: 0; ReparierteTeilschalen: 0; Netzaufbau: konforme Materialvereinigung ohne innere Dreiecksflächen; IFCAbschlusstoleranz_m: 0
Name | Description = Beschreibung | Einheitstyp | Typkenner | Kenner | DreieckeGesamt | Netzknoten | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m) | Instanz | Entstehungsfolge | ZulaessigeSchichten | Reichweite_m | RangeLokal_m | OffsetLokal_m = OffsetLokalGespeichert_m = ÜberlagerungspunkteRaster | OffsetLokalAktiv | Endform | Grundrissform = WirksameGrundrissform | Mittelpunktmodus | Linsenverteilung | Zufallsbereich | Koerperrolle | ZusaetzlicheZufallslinse | ZusaetzlicheLinsenAnzahl | ZufallsbreiteMin_m | ZufallsbreiteMax_m | ZufallshoeheMin_m | ZufallshoeheMax_m | Koerperbreite_m | MaximaleMaechtigkeit_m | Pflichtvorkommen = Stützstellenbindung | NullnachweisQuelle = BandueberschneidungenZulaessig | TeilkörperIndex | Quellstützstelle | Vorkommensindex | Grundrissmittelpunkt | AuskeilenderRand
Auffüllung – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Auffüllung – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S1 | 238360 | 119182 | 166447 | 80077.1 | 0.897034 | 5.06628 | 2.07859 | Pset_rbfSBL_Geologie - Reihenfolge: 1; Obergrenze: OK_S1; Untergrenze: OK_S2; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 0; DurchZusatzkoerperErsetzt: yes
Sand/Kies – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Sand/Kies – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S2 | 238360 | 119182 | 523861 | 80077.1 | 5.46365 | 8.24684 | 6.54196 | Pset_rbfSBL_Geologie - Reihenfolge: 2; Obergrenze: OK_S2; Untergrenze: OK_S3; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 10; DurchZusatzkoerperErsetzt: yes
Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S3 | 238360 | 119182 | 464433 | 80077.1 | 4.6077 | 6.8688 | 5.79982 | Pset_rbfSBL_Geologie - Reihenfolge: 3; Obergrenze: OK_S3; Untergrenze: OK_S4; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 10; DurchZusatzkoerperErsetzt: yes
Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S4 | 238360 | 119182 | 321777 | 80077.1 | 1.08649 | 5.47362 | 4.01834 | Pset_rbfSBL_Geologie - Reihenfolge: 4; Obergrenze: OK_S4; Untergrenze: OK_S5; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 0; DurchZusatzkoerperErsetzt: yes
Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | Schicht | S | S5 | 268318 | 134165 | 789739 | 80077.1 | 0.156296 | 10 | 9.86224 | Pset_rbfSBL_Geologie - Reihenfolge: 5; Obergrenze: OK_S5; Untergrenze: Modellunterkante (Darstellungsabschluss); Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: no; GrenzeinheitenBeschneidung: 0; DurchZusatzkoerperErsetzt: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 1948 | 976 | 711.751 | 663.762 | 0.000634475 | 1.93856 | 1.0723 | 6 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 2 | ZUFALL_02 | 0 | [835.1195948026078, 80.28131999595684] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -688301264; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 2028 | 1016 | 576.842 | 681.411 | 0.0000496525 | 1.5 | 0.846541 | 2 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 2 | TUN_ST_020 | 1 | [742.511823, 52.665269] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -311762245; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 1562 | 783 | 423.911 | 522.178 | 0.0000509338 | 1.5 | 0.811813 | 4 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 4 | TUN_ST_047 | 1 | [1825.133073, 46.074187] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 19861010; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 2112 | 1058 | 599.619 | 709.333 | 0.00159749 | 1.5 | 0.845328 | 3 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 3 | TUN_ST_034 | 1 | [1315.796662, 68.297494] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -680111125; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 1502 | 753 | 410.621 | 501.991 | 0.00255773 | 1.5 | 0.817985 | 1 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 1 | TUN_ST_007 | 1 | [238.728559, 47.779944] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 1793231275; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 2494 | 1249 | 970.534 | 842.892 | 0.00000120905 | 1.98815 | 1.15143 | 7 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 3 | ZUFALL_03 | 0 | [1203.9939769793982, 36.59272747126595] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -688301264; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 4400 | 2202 | 1819.81 | 1490.41 | 0.000108029 | 2 | 1.22101 | 3 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 3 | TUN_ST_040 | 1 | [1557.566222, 78.586396] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -640249404; ZufallslinsenKollisionsfrei: yes
