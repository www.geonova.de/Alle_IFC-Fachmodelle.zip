Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 2

# IfcGeotechnicalStratum: Geotechnical stratum (68)
Name | Description = Beschreibung | Erdarbeiten = Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Homogenbereich | Bohrarbeiten = Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Homogenbereich | Ramm-, Rüttel- und Pressarbeiten = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Homogenbereich | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Nummer Bauleistung | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Massenanteil Co/Bo/Lbo_min = Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Massenanteil Co/Bo/Lbo_min = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Massenanteil Co/Bo/Lbo_min | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Massenanteil Co/Bo/Lbo_max | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Massenanteil Co/Bo/Lbo: Vorschrift = Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Massenanteil Co/Bo/Lbo: Vorschrift = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Massenanteil Co/Bo/Lbo: Vorschrift | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Bodengruppe Erd-/Grundbau | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09, Bodengruppe Erd-/Grundbau: Vorschrift = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Bodengruppe Erd-/Grundbau: Vorschrift | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Nummer Bauleistung | Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09, Massenanteil Co/Bo/Lbo_max = Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Massenanteil Co/Bo/Lbo_max | A_Br_min | A_Br_max | A_Br: Vorschrift | Bezeichnung Bauleistung | Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Nummer Bauleistung | Pset_Ramm_Rüttel_und_Pressarbeiten_gemäß_DIN_18304_2019_09, Bodengruppe Erd-/Grundbau | Einheitstyp | Kenner | DreieckeGrundriss | DreieckeGesamt | Netzknoten | TechnischeAbschlussknoten | DirektVernetzteLinsenkörper | Netzaufbau | IFCAbschlusstoleranz_m | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m) | Punktart | Punktname | Oberkante_m | Unterkante_m | Maechtigkeit_m
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.67674 | 0.785398 | 3.40814 | 3.40814 | 3.40814 | Stützstelle | ST_BKF_7 | 23.0481 | 19.64 | 3.40814 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.16814 | 0.785398 | 10.4 | 10.4 | 10.4 | Stützstelle | ST_BKF_7 | 19.64 | 9.24 | 10.4 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | GL | G1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.64934 | 0.785398 | 2.1 | 2.1 | 2.1 | Stützstelle | ST_BKF_7 | 9.24 | 7.14 | 2.1 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Schluff; Bodengruppe Erd-/Grundbau: UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 35; w_Boden_max: 54; w_Boden_mittel: 46.5; w_Boden: Anzahl Laborversuche: 4; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 4.2; I_P_max: 6.4; I_P_mittel: 4.5; I_P: Anzahl Laborversuche: 4; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 17.5; gamma_feucht_Boden_max: 19; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 10; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 20; phi_eff_min: 25; phi_eff_max: 27.5; E_S_Erstbel_min: 2 m; E_S_Erstbel_max: 4 m
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 5.89049 | 0.785398 | 7.5 | 7.5 | 7.5 | Stützstelle | ST_BKF_7 | 7.14 | -0.36 | 7.5 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 5.18363 | 0.785398 | 6.6 | 6.6 | 6.6 | Stützstelle | ST_BKF_7 | -0.36 | -6.96 | 6.6 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.775 | 0.785398 | 2.26 | 2.26 | 2.26 | Stützstelle | ST_BKF_GW_8 | 23.1 | 20.84 | 2.26 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 10.5243 | 0.785398 | 13.4 | 13.4 | 13.4 | Stützstelle | ST_BKF_GW_8 | 20.84 | 7.44 | 13.4 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.83296 | 0.785398 | 8.7 | 8.7 | 8.7 | Stützstelle | ST_BKF_GW_8 | 7.44 | -1.26 | 8.7 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 4.47677 | 0.785398 | 5.7 | 5.7 | 5.7 | Stützstelle | ST_BKF_GW_8 | -1.26 | -6.96 | 5.7 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.28735 | 0.785398 | 1.6391 | 1.6391 | 1.6391 | Stützstelle | ST_BKF_9 | 23.0791 | 21.44 | 1.6391 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.01106 | 0.785398 | 10.2 | 10.2 | 10.2 | Stützstelle | ST_BKF_9 | 21.44 | 11.24 | 10.2 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.56084 | 0.785398 | 10.9 | 10.9 | 10.9 | Stützstelle | ST_BKF_9 | 11.24 | 0.34 | 10.9 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 5.73341 | 0.785398 | 7.3 | 7.3 | 7.3 | Stützstelle | ST_BKF_9 | 0.34 | -6.96 | 7.3 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.01739 | 0.785398 | 2.56862 | 2.56862 | 2.56862 | Stützstelle | ST_BKF_10 | 23.5086 | 20.94 | 2.56862 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.95354 | 0.785398 | 11.4 | 11.4 | 11.4 | Stützstelle | ST_BKF_10 | 20.94 | 9.54 | 11.4 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | GL | G1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.04204 | 0.785398 | 2.6 | 2.6 | 2.6 | Stützstelle | ST_BKF_10 | 9.54 | 6.94 | 2.6 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Schluff; Bodengruppe Erd-/Grundbau: UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 35; w_Boden_max: 54; w_Boden_mittel: 46.5; w_Boden: Anzahl Laborversuche: 4; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 4.2; I_P_max: 6.4; I_P_mittel: 4.5; I_P: Anzahl Laborversuche: 4; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 17.5; gamma_feucht_Boden_max: 19; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 10; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 20; phi_eff_min: 25; phi_eff_max: 27.5; E_S_Erstbel_min: 2 m; E_S_Erstbel_max: 4 m
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.34347 | 0.785398 | 9.35 | 9.35 | 9.35 | Stützstelle | ST_BKF_10 | 6.94 | -2.41 | 9.35 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 3.57356 | 0.785398 | 4.55 | 4.55 | 4.55 | Stützstelle | ST_BKF_10 | -2.41 | -6.96 | 4.55 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.35265 | 0.785398 | 2.99548 | 2.99548 | 2.99548 | Stützstelle | ST_CPT_1 | 22.9355 | 19.94 | 2.99548 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.77544 | 0.785398 | 9.9 | 9.9 | 9.9 | Stützstelle | ST_CPT_1 | 19.94 | 10.04 | 9.9 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.99004 | 0.785398 | 8.9 | 8.9 | 8.9 | Stützstelle | ST_CPT_1 | 10.04 | 1.14 | 8.9 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.36173 | 0.785398 | 8.1 | 8.1 | 8.1 | Stützstelle | ST_CPT_1 | 1.14 | -6.96 | 8.1 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 4.05265 | 0.785398 | 5.16 | 5.16 | 5.16 | Stützstelle | ST_CPT_2 | 25.9 | 20.74 | 5.16 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.32522 | 0.785398 | 10.6 | 10.6 | 10.6 | Stützstelle | ST_CPT_2 | 20.74 | 10.14 | 10.6 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.38274 | 0.785398 | 9.4 | 9.4 | 9.4 | Stützstelle | ST_CPT_2 | 10.14 | 0.74 | 9.4 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.04757 | 0.785398 | 7.7 | 7.7 | 7.7 | Stützstelle | ST_CPT_2 | 0.74 | -6.96 | 7.7 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 2.87456 | 0.785398 | 3.66 | 3.66 | 3.66 | Stützstelle | ST_CPT_3 | 24.1 | 20.44 | 3.66 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.71792 | 0.785398 | 11.1 | 11.1 | 11.1 | Stützstelle | ST_CPT_3 | 20.44 | 9.34 | 11.1 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 9.03208 | 0.785398 | 11.5 | 11.5 | 11.5 | Stützstelle | ST_CPT_3 | 9.34 | -2.16 | 11.5 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 3.76991 | 0.785398 | 4.8 | 4.8 | 4.8 | Stützstelle | ST_CPT_3 | -2.16 | -6.96 | 4.8 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.70001 | 0.785398 | 2.16453 | 2.16453 | 2.16453 | Stützstelle | ST_CPT_4 | 23.1045 | 20.94 | 2.16453 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 8.63938 | 0.785398 | 11 | 11 | 11 | Stützstelle | ST_CPT_4 | 20.94 | 9.94 | 11 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.75442 | 0.785398 | 8.6 | 8.6 | 8.6 | Stützstelle | ST_CPT_4 | 9.94 | 1.34 | 8.6 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 6.5188 | 0.785398 | 8.3 | 8.3 | 8.3 | Stützstelle | ST_CPT_4 | 1.34 | -6.96 | 8.3 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06
Auffüllung | Auffüllung | Erd 01 | Bohr 01 | RRP 01 | 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S1 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 1.78285 | 0.785398 | 2.27 | 2.27 | 2.27 | Stützstelle | ST_CPT_5 | 23.01 | 20.74 | 2.27 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Erd 02 | Bohr 01 | RRP 01 | 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | 01 | 15 | 250 | 750 | NF P18-579:2013-02-09 | RRP | 01 | GW, GI, SW, SI, GU, GU*, SU, SU*, UL | S | S2 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 9.03208 | 0.785398 | 11.5 | 11.5 | 11.5 | Stützstelle | ST_CPT_5 | 20.74 | 9.24 | 11.5 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Erd 03 | Bohr 02 | RRP 02 | 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | 02 | 5 | 100 | 300 | NF P18-579:2013-02-09 | RRP | 02 | UL, TL, TM, TA | S | S3 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 7.3042 | 0.785398 | 9.3 | 9.3 | 9.3 | Stützstelle | ST_CPT_5 | 9.24 | -0.06 | 9.3 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Erd 04 | Bohr 03 |  | 04 |  |  |  |  |  | 03 |  |  |  |  |  |  |  | S | S4 | 0 | 96 | 50 | 0 | 0 | analytischer geschlossener Zylinder | 0 | 5.41925 | 0.785398 | 6.9 | 6.9 | 6.9 | Stützstelle | ST_CPT_5 | -0.06 | -6.96 | 6.9 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m; Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Pset_Bohrarbeiten_gemäß_DIN_18301_2019_09 - Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; CAI_min: 0.5; CAI_max: 3; CAI: Vorschrift: Empfehlung Nr. 23 des AK 3.3 der DGGT:2016-06

# IfcGeotechnicalStratum: Groundwater stratum, Grundwasserleiter Quartär
Description: Grundwasserleiter Quartär; PredefinedType: WATER
Pset_Grundwasser - Bezeichnung: Quartärwasserleiter; Auftretenswahrscheinlichkeit_T: 50; Fliessrichtung_von: SW; Fliessrichtung_nach: NO; Expositionsklasse Betonaggressivität: XA1; Betonaggressivität: Vorschrift: DIN 4030-1:2008-06; Bemessungsgrundwasserstand_charakteristisch_mittel: 18 m; Interpolationsverfahren_Messwasserstände: Radiale Basisfunktionen (RBF); Höhenbezug: DHHN2016 / mNHN / EPSG:7837; Schnittdarstellung: Messwasserstände: blaue Volllinie; Bemessungsgrundwasserstand: blaue gestrichelte Linie; Gemessene_Wasserstände_Anzahl: 10; Gemessener_Wasserstand_minimal: 17.64 m; Gemessener_Wasserstand_maximal: 18.9 m; Modellierte_Messwasserstandslinie: RBF-Interpolation aus gemessenen Wasserständen; Schichtbezug: S2
