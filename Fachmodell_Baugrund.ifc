Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 2

# IfcGeotechnicalStratum: Geotechnical stratum (27)
Name | Description = Beschreibung | Einheitstyp | Typkenner | Kenner | DreieckeGesamt | Netzknoten | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m) | Instanz | Entstehungsfolge | ZulaessigeSchichten | Reichweite_m | RangeLokal_m | OffsetLokal_m = OffsetLokalGespeichert_m = ÜberlagerungspunkteRaster | OffsetLokalAktiv | Endform | Grundrissform = WirksameGrundrissform | Mittelpunktmodus | Linsenverteilung | Zufallsbereich | Koerperrolle | ZusaetzlicheZufallslinse | ZusaetzlicheLinsenAnzahl | ZufallsbreiteMin_m | ZufallsbreiteMax_m | ZufallshoeheMin_m | ZufallshoeheMax_m | Koerperbreite_m | MaximaleMaechtigkeit_m | Pflichtvorkommen = Stützstellenbindung | NullnachweisQuelle = BandueberschneidungenZulaessig | TeilkörperIndex | Quellstützstelle | Vorkommensindex | Grundrissmittelpunkt | AuskeilenderRand
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 2756 | 1380 | 1130.4 | 937.215 | 0.00000215764 | 2 | 1.20612 | 1 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 1 | TUN_ST_012 | 1 | [436.490202, 86.778002] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -2066358431; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 3530 | 1767 | 1456.64 | 1175.55 | 7.25404e-07 | 2 | 1.23912 | 2 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 2 | TUN_ST_028 | 1 | [1068.137375, 39.421828] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -1910537428; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 4018 | 2011 | 1709.28 | 1349.81 | 9.04424e-08 | 2 | 1.26632 | 4 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 4 | TUN_ST_050 | 1 | [1954.663535, 17.653917] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 824802600; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 1318 | 661 | 430.607 | 469.289 | 0.0000179001 | 1.72958 | 0.917574 | 8 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 4 | ZUFALL_04 | 0 | [965.5422530667469, 18.454621478881226] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 938013926; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 2202 | 1103 | 791.722 | 737.841 | 0.00022382 | 1.95743 | 1.07302 | 5 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 1 | ZUFALL_01 | 0 | [696.1673183848042, 88.84486015423543] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 938013926; ZufallslinsenKollisionsfrei: yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1666 | 835 | 521.562 | 558.372 | 0.000300767 | 1.56882 | 0.934076 | 4 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 4 | TUN_ST_022 | 1 | [825.68476, 42.416787] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1944 | 974 | 468.513 | 652.586 | 0.00233304 | 1.29414 | 0.717933 | 3 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 3 | TUN_ST_021 | 1 | [793.73492, 63.901296] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1848 | 926 | 562.064 | 611.775 | 0.00598335 | 1.56882 | 0.918744 | 7 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 7 | TUN_ST_041 | 1 | [1595.079818, 63.200094] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1956 | 980 | 568.881 | 657.637 | 0.000794871 | 1.56882 | 0.865038 | 8 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 8 | TUN_ST_043 | 1 | [1663.674154, 59.663276] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1552 | 778 | 478.457 | 519.723 | 0.000101753 | 1.56882 | 0.920601 | 9 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 9 | TUN_ST_045 | 1 | [1735.854274, 43.86339] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1696 | 850 | 512.878 | 568.519 | 1.31093e-07 | 1.56882 | 0.90213 | 2 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 2 | TUN_ST_009 | 1 | [306.872207, 53.268704] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1796 | 900 | 444.906 | 597.394 | 0.0000475152 | 1.29414 | 0.744745 | 1 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 1 | TUN_ST_006 | 1 | [185.802527, 32.962736] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1906 | 955 | 459.423 | 624.198 | 7.79877e-08 | 1.29414 | 0.736022 | 6 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 6 | TUN_ST_028 | 1 | [1068.137375, 39.421828] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1744 | 874 | 438.664 | 565.367 | 0.000139237 | 1.29414 | 0.775893 | 5 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 5 | TUN_ST_026 | 1 | [987.281026, 36.569394] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1882 | 943 | 452.902 | 622.032 | 0.00000216323 | 1.29414 | 0.728101 | 10 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 10 | TUN_ST_049 | 1 | [1909.213263, 31.047542] | yes
