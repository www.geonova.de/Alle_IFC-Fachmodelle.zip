Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Homogenbereiche.ifc.tmp
Time: 2026-10-03T13:20:41+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, Tunnel – V0
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, Tunnel – V0
Description: Projektstandort; LongName: Tunnel – V0

# IfcGeomodel: rbfSBL IfcGeomodel, Tunnel – V0 – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_rbfSBL_ProjectInformation - ProjectName: Tunnel; Description: Fiktive Übertragung aus DGGT-Beispiel; kein Ortsaufschluss und keine Bemessungsgrundlage.; Status: Fiktives Testprojekt; CreationDate: 2026-09-30; ModifiedDate: 2026-10-03; CoordinateReferenceSystem: lokales fiktives XY [m]; HeightReferenceSystem: lokales synthetisches Höhensystem [m]

# IfcGeotechnicalStratum: Geotechnical stratum (27)
PredefinedType: SOLID
Pset_rbfSBL_Geologie - GemeinsameMaterialpartition: yes; Geometrieart: IfcTriangulatedFaceSet; GeschlosseneTeilkörper: 1; DreieckeGrundriss: 0; OffeneNetzkanten: 0; TechnischeAbschlussknoten: 0; DirektVernetzteLinsenkörper: 0; ReparierteTeilschalen: 0; Netzaufbau: konforme Materialvereinigung ohne innere Dreiecksflächen; IFCAbschlusstoleranz_m: 0
Name | Description = Beschreibung | Einheitstyp | Typkenner | Kenner | DreieckeGesamt | Netzknoten | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m) | Instanz | Entstehungsfolge | ZulaessigeSchichten | Reichweite_m | RangeLokal_m | OffsetLokal_m = OffsetLokalGespeichert_m = ÜberlagerungspunkteRaster | OffsetLokalAktiv | Endform | Grundrissform = WirksameGrundrissform | Mittelpunktmodus | Linsenverteilung | Zufallsbereich | Koerperrolle | ZusaetzlicheZufallslinse | ZusaetzlicheLinsenAnzahl | ZufallsbreiteMin_m | ZufallsbreiteMax_m | ZufallshoeheMin_m | ZufallshoeheMax_m | Koerperbreite_m | MaximaleMaechtigkeit_m | Pflichtvorkommen = Stützstellenbindung | NullnachweisQuelle = BandueberschneidungenZulaessig | TeilkörperIndex | Quellstützstelle | Vorkommensindex | Grundrissmittelpunkt | AuskeilenderRand
Auffüllung – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Auffüllung – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S1 | 238360 | 119182 | 166447 | 80077.1 | 0.897034 | 5.06628 | 2.07859 | Pset_rbfSBL_Geologie - Reihenfolge: 1; Obergrenze: OK_S1; Untergrenze: OK_S2; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 0; DurchZusatzkoerperErsetzt: yes
Sand/Kies – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Sand/Kies – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S2 | 238360 | 119182 | 523861 | 80077.1 | 5.46365 | 8.24684 | 6.54196 | Pset_rbfSBL_Geologie - Reihenfolge: 2; Obergrenze: OK_S2; Untergrenze: OK_S3; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 10; DurchZusatzkoerperErsetzt: yes
Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Lösslehm – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S3 | 238360 | 119182 | 464433 | 80077.1 | 4.6077 | 6.8688 | 5.79982 | Pset_rbfSBL_Geologie - Reihenfolge: 3; Obergrenze: OK_S3; Untergrenze: OK_S4; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 10; DurchZusatzkoerperErsetzt: yes
Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Sand- und Schluffstein – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schicht | S | S4 | 238360 | 119182 | 321777 | 80077.1 | 1.08649 | 5.47362 | 4.01834 | Pset_rbfSBL_Geologie - Reihenfolge: 4; Obergrenze: OK_S4; Untergrenze: OK_S5; Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: yes; GrenzeinheitenBeschneidung: 0; DurchZusatzkoerperErsetzt: yes
Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | Tonstein V3, zusätzliche 10 m – fiktiv; Gutachten-Schichtnummer offen | Schicht | S | S5 | 268318 | 134165 | 789739 | 80077.1 | 0.156296 | 10 | 9.86224 | Pset_rbfSBL_Geologie - Reihenfolge: 5; Obergrenze: OK_S5; Untergrenze: Modellunterkante (Darstellungsabschluss); Grenzflächenvariante: z_safety (superponiert); DGMAlsOberkante: no; UntersterAbschlussIstInterpretierteGrenze: no; GrenzeinheitenBeschneidung: 0; DurchZusatzkoerperErsetzt: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 1948 | 976 | 711.751 | 663.762 | 0.000634475 | 1.93856 | 1.0723 | 6 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 2 | ZUFALL_02 | 0 | [835.1195948026078, 80.28131999595684] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -688301264; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 2028 | 1016 | 576.842 | 681.411 | 0.0000496525 | 1.5 | 0.846541 | 2 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 2 | TUN_ST_020 | 1 | [742.511823, 52.665269] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -311762245; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 1562 | 783 | 423.911 | 522.178 | 0.0000509338 | 1.5 | 0.811813 | 4 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 4 | TUN_ST_047 | 1 | [1825.133073, 46.074187] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 19861010; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 2112 | 1058 | 599.619 | 709.333 | 0.00159749 | 1.5 | 0.845328 | 3 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 3 | TUN_ST_034 | 1 | [1315.796662, 68.297494] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -680111125; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 1502 | 753 | 410.621 | 501.991 | 0.00255773 | 1.5 | 0.817985 | 1 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 32.5 | 1.5 | yes | no | 1 | TUN_ST_007 | 1 | [238.728559, 47.779944] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 1793231275; ZufallslinsenKollisionsfrei: yes
Tonstein V2, fiktive interne Linse in Tonstein V3 | Tonstein V2, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV2 | 2494 | 1249 | 970.534 | 842.892 | 0.00000120905 | 1.98815 | 1.15143 | 7 | 8 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 3 | ZUFALL_03 | 0 | [1203.9939769793982, 36.59272747126595] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -688301264; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 4400 | 2202 | 1819.81 | 1490.41 | 0.000108029 | 2 | 1.22101 | 3 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 3 | TUN_ST_040 | 1 | [1557.566222, 78.586396] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -640249404; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 2756 | 1380 | 1130.4 | 937.215 | 0.00000215764 | 2 | 1.20612 | 1 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 1 | TUN_ST_012 | 1 | [436.490202, 86.778002] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -2066358431; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 3530 | 1767 | 1456.64 | 1175.55 | 7.25404e-07 | 2 | 1.23912 | 2 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 2 | TUN_ST_028 | 1 | [1068.137375, 39.421828] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: -1910537428; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 4018 | 2011 | 1709.28 | 1349.81 | 9.04424e-08 | 2 | 1.26632 | 4 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Nachweislinse | no | 4 | 15 | 50 | 1 | 2 | 50 | 2 | yes | no | 4 | TUN_ST_050 | 1 | [1954.663535, 17.653917] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 824802600; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 1318 | 661 | 430.607 | 469.289 | 0.0000179001 | 1.72958 | 0.917574 | 8 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 4 | ZUFALL_04 | 0 | [965.5422530667469, 18.454621478881226] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 938013926; ZufallslinsenKollisionsfrei: yes
Tonstein V4, fiktive interne Linse in Tonstein V3 | Tonstein V4, fiktive interne Linse in Tonstein V3 | Freie Linse | L | TV4 | 2202 | 1103 | 791.722 | 737.841 | 0.00022382 | 1.95743 | 1.07302 | 5 | 9 | S5 | 80 | 80 | 0 | no | abgerundet | elliptisch | Zufallskörper | mehrere Zufallslinsen | gesamtes Modellgebiet | Zusatzlinse | yes | 4 | 15 | 50 | 1 | 2 | 50 | 2 | no | no | 1 | ZUFALL_01 | 0 | [696.1673183848042, 88.84486015423543] | yes | Pset_rbfSBL_Geologie - KollisionenZulaessig: no; Zufallsseed: 938013926; ZufallslinsenKollisionsfrei: yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1666 | 835 | 521.562 | 558.372 | 0.000300767 | 1.56882 | 0.934076 | 4 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 4 | TUN_ST_022 | 1 | [825.68476, 42.416787] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1944 | 974 | 468.513 | 652.586 | 0.00233304 | 1.29414 | 0.717933 | 3 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 3 | TUN_ST_021 | 1 | [793.73492, 63.901296] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1848 | 926 | 562.064 | 611.775 | 0.00598335 | 1.56882 | 0.918744 | 7 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 7 | TUN_ST_041 | 1 | [1595.079818, 63.200094] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1956 | 980 | 568.881 | 657.637 | 0.000794871 | 1.56882 | 0.865038 | 8 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 8 | TUN_ST_043 | 1 | [1663.674154, 59.663276] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1552 | 778 | 478.457 | 519.723 | 0.000101753 | 1.56882 | 0.920601 | 9 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 9 | TUN_ST_045 | 1 | [1735.854274, 43.86339] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1696 | 850 | 512.878 | 568.519 | 1.31093e-07 | 1.56882 | 0.90213 | 2 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.56882 | yes | no | 2 | TUN_ST_009 | 1 | [306.872207, 53.268704] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1796 | 900 | 444.906 | 597.394 | 0.0000475152 | 1.29414 | 0.744745 | 1 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 1 | TUN_ST_006 | 1 | [185.802527, 32.962736] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1906 | 955 | 459.423 | 624.198 | 7.79877e-08 | 1.29414 | 0.736022 | 6 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 6 | TUN_ST_028 | 1 | [1068.137375, 39.421828] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1744 | 874 | 438.664 | 565.367 | 0.000139237 | 1.29414 | 0.775893 | 5 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 5 | TUN_ST_026 | 1 | [987.281026, 36.569394] | yes
Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Schluff-Grenzlinse (auskeilende Zwischenschicht) – fiktiv aus DGGT übertragen; Gutachten-Schichtnummer offen | Grenzlinse | GL | G1 | 1882 | 943 | 452.902 | 622.032 | 0.00000216323 | 1.29414 | 0.728101 | 10 | 5 | S2, S3 | 16.5 | 5 | 0 | yes | abgerundet | elliptisch | Stützstelle | ein Körper | abgeleiteter Einflussbereich | Einzellinse | no | 1 | 1.98 | 14.85 | 1.05 | 2.6 | 33 | 1.29414 | yes | no | 10 | TUN_ST_049 | 1 | [1909.213263, 31.047542] | yes
