Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Homogenbereiche_Erd.ifc.tmp
Time: 2026-09-15T21:58:44+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, DGGT Beispiel – Vorgabe DGGT
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, DGGT Beispiel – Vorgabe DGGT
Description: Projektstandort; LongName: DGGT Beispiel – Vorgabe DGGT

# IfcBuildingElementProxy: Homogeneous area (4)
Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd
Name | Description | Nummer Bauleistung | Homogenbereich | Massenanteil Co/Bo/Lbo_min | Massenanteil Co/Bo/Lbo_max | Massenanteil Co/Bo/Lbo: Vorschrift | Bodengruppe Erd-/Grundbau | Bodengruppe Erd-/Grundbau: Vorschrift
Erd 01 | Erdarbeiten – Erd 01 | 01 | Erd 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05
Erd 02 | Erdarbeiten – Erd 02 | 02 | Erd 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05
Erd 03 | Erdarbeiten – Erd 03 | 03 | Erd 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05
Erd 04 | Erdarbeiten – Erd 04 | 04 | Erd 04 | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10

# IfcGeomodel: rbfSBL IfcGeomodel, DGGT Beispiel – Vorgabe DGGT – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_Allgemeine_Projektinformationen - Projektname: Testprojekt-Fachmodell_Baugrund; Modellautor: z. B. Jörg Bauer; Fachautor: z. B. Jörg Bauer; Datum der Erstellung: z. B. 24.06.2021; Datum der letzten Änderung: z. B. 07.07.2021; Entwicklungsstufe: Genehmigungsplanung; Koordinatensystem_Lage: Koordinatensystem_Lage: lokal; Lage_Status: ETRS89 / UTM zone 32N; Koordinatensystem_Höhe: DHHN2016; EPSG-Code_Koordinatensystem_Lage: -; EPSG-Code_Koordinatensystem_Höhe: 7837; Geotechnische Kategorie: GK3; Geotechnische Kategorie: Vorschrift: DIN 4020:2010-12; Erdbebenzone: 0; Erdbeben Baugrundklasse: C; Erdbeben Untergrundklasse: R; Erdbebengefährdung: Vorschrift: DIN EN 1998-1:2010-12 / DIN EN 1998-1/A1:2013-05; Höhensystem_Status: DHHN2016 / mNHN
Pset_rbfSBL_ProjectInformation - ProjectName: DGGT Beispiel; ProjectNumber: DGGT-Testprojekt-26-08-31-IFC-Varianten; Responsible: Geonova; Author: Geonova; Organization: Geonova; ModelAuthor: Geonova; DisciplineAuthor: Geonova; Description: DGGT-Testprojekt mit mehreren IFC-/Property-Set-Datensätzen für SVG/HTML und IFC4X3_ADD2.; ProjectPhase: Genehmigungsplanung; CreationDate: 2026-09-15; ModifiedDate: 2026-09-15; CoordinateReferenceSystem: lokal; ETRS89 / UTM zone 32N; EPSG-Code nicht angegeben; HeightReferenceSystem: DHHN2016 / mNHN / EPSG:7837; Notes: Projektphase: Genehmigungsplanung DGGT-Testprojekt: 15 einzelne BKF/CPT als IfcBorehole mit Erkundungsattributen und SVG-Zuordnung angereichert.

# IfcGeotechnicalStratum: Geotechnical stratum (6)
PredefinedType: SOLID
Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - Bezeichnung Bauleistung: Erd
Pset_rbfSBL_Geologie - Geometrieart: IfcTriangulatedFaceSet; GeschlosseneTeilkörper: 1; OffeneNetzkanten: 0; ReparierteTeilschalen: 0; Netzaufbau: geschlossenes gemeinsames Netz
Name | Description = Beschreibung | Nummer Bauleistung | Homogenbereich | Massenanteil Co/Bo/Lbo_min | Massenanteil Co/Bo/Lbo_max | Massenanteil Co/Bo/Lbo: Vorschrift | Bodengruppe Erd-/Grundbau | Bodengruppe Erd-/Grundbau: Vorschrift | Einheitstyp | Typkenner | Kenner | Reihenfolge | Obergrenze | Untergrenze | Grenzflächenvariante | DGMAlsOberkante | UntersterAbschlussIstInterpretierteGrenze | GrenzeinheitenBeschneidung | RestkoerperIndex | DurchZusatzkoerperErsetzt | DreieckeGrundriss | DreieckeGesamt | Netzknoten | TechnischeAbschlussknoten | DirektVernetzteLinsenkörper | IFCAbschlusstoleranz_m | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m)
Auffüllung | Auffüllung | 01 | Erd 01 | 0 | 15 | DIN EN ISO 17892-4:2017-04 | GI, SI, GU, GU*, SU, SU*, UL | DIN 18196:2011-05 | Schicht | S | S1 | 1 | OK_S1 | OK_S2 | z_safety (superponiert) | yes | yes | 0 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 18359.5 | 6000 | 1.48944 | 8.61814 | 3.05991
Sand/Kies | Sand/Kies | 02 | Erd 02 | 0 | 10 | DIN EN ISO 17892-4:2017-04 | GW, GI, SW, SI, GU, GU*, SU, SU* | DIN 18196:2011-05 | Schicht | S | S2 | 2 | OK_S2 | OK_S3 | z_safety (superponiert) | no | yes | 2 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 65613.8 | 6000 | 9.36364 | 13.4054 | 10.9356
Lösslehm | Lösslehm | 03 | Erd 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | Schicht | S | S3 | 3 | OK_S3 | OK_S4 | z_safety (superponiert) | no | yes | 2 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 58079.9 | 6000 | 7.49684 | 11.5308 | 9.67998
Sand- und Schluffstein | Sand- und Schluffstein | 04 | Erd 04 |  |  |  |  |  | Schicht | S | S4 | 4 | OK_S4 | Modellunterkante (Darstellungsabschluss) | z_safety (superponiert) | no | no | 0 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 40480.6 | 6000 | 3.79021 | 8.4154 | 6.74676 | Pset_Erdarbeiten_gemäß_DIN_18300_2019_09 - rho_Fels_min: 2; rho_Fels_max: 2.65; rho_Fels: Vorschrift: DIN EN ISO 17892-2:2015-03; Einaxiale Druckfestigkeit_min: 20; Einaxiale Druckfestigkeit_max: 90; Einaxiale Druckfestigkeit: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | 03 | Erd 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | Grenzlinse | GL | G1 |  |  |  |  |  |  |  |  |  | 4960 | 10240 | 5122 | 160 | 1 | 0.000001 | 757.046 | 555.655 | 0.000001 | 2.1 | 1.36244 | Pset_rbfSBL_Geologie - Instanz: 2; Entstehungsfolge: 5; ZulaessigeSchichten: S2, S3; Reichweite_m: 16.5; RangeLokal_m: 5; OffsetLokal_m: 0; OffsetLokalAktiv: yes; OffsetLokalGespeichert_m: 0; Endform: abgerundet; Grundrissform: elliptisch; WirksameGrundrissform: elliptisch; Mittelpunktmodus: Stützstelle; Linsenverteilung: ein Körper; Zufallsbereich: abgeleiteter Einflussbereich; Koerperrolle: Einzellinse; ZusaetzlicheZufallslinse: no; ZusaetzlicheLinsenAnzahl: 1; ZufallsbreiteMin_m: 1.98; ZufallsbreiteMax_m: 14.85; ZufallshoeheMin_m: 1.05; ZufallshoeheMax_m: 2.6; Koerperbreite_m: 33; MaximaleMaechtigkeit_m: 2.1; Pflichtvorkommen: yes; NullnachweisQuelle: no; TeilkörperIndex: 2; Stützstellenbindung: yes; Quellstützstelle: ST_BKF_7; Vorkommensindex: 1; Grundrissmittelpunkt: [48.4, 26.6]; AuskeilenderRand: yes; ÜberlagerungspunkteRaster: 0; BandueberschneidungenZulaessig: no
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | 03 | Erd 03 | 0 | 5 | DIN EN ISO 17892-4:2017-04 | UL, TL, TM, TA | DIN 18196:2011-05 | Grenzlinse | GL | G1 |  |  |  |  |  |  |  |  |  | 4960 | 10240 | 5122 | 49 | 1 | 0.000001 | 401.578 | 226.048 | 0.000001 | 2.6 | 1.77652 | Pset_rbfSBL_Geologie - Instanz: 1; Entstehungsfolge: 5; ZulaessigeSchichten: S2, S3; Reichweite_m: 16.5; RangeLokal_m: 5; OffsetLokal_m: 0; OffsetLokalAktiv: yes; OffsetLokalGespeichert_m: 0; Endform: abgerundet; Grundrissform: elliptisch; WirksameGrundrissform: elliptisch; Mittelpunktmodus: Stützstelle; Linsenverteilung: ein Körper; Zufallsbereich: abgeleiteter Einflussbereich; Koerperrolle: Einzellinse; ZusaetzlicheZufallslinse: no; ZusaetzlicheLinsenAnzahl: 1; ZufallsbreiteMin_m: 1.98; ZufallsbreiteMax_m: 14.85; ZufallshoeheMin_m: 1.05; ZufallshoeheMax_m: 2.6; Koerperbreite_m: 33; MaximaleMaechtigkeit_m: 2.6; Pflichtvorkommen: yes; NullnachweisQuelle: no; TeilkörperIndex: 1; Stützstellenbindung: yes; Quellstützstelle: ST_BKF_10; Vorkommensindex: 1; Grundrissmittelpunkt: [2.6, 1.5]; AuskeilenderRand: yes; ÜberlagerungspunkteRaster: 0; BandueberschneidungenZulaessig: no
