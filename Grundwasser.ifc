Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Grundwasser.ifc.tmp
Time: 2026-09-15T21:58:33+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, DGGT Beispiel – Vorgabe DGGT
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, DGGT Beispiel – Vorgabe DGGT
Description: Projektstandort; LongName: DGGT Beispiel – Vorgabe DGGT

# IfcGeomodel: rbfSBL IfcGeomodel, DGGT Beispiel – Vorgabe DGGT – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_Allgemeine_Projektinformationen - Projektname: Testprojekt-Fachmodell_Baugrund; Modellautor: z. B. Jörg Bauer; Fachautor: z. B. Jörg Bauer; Datum der Erstellung: z. B. 24.06.2021; Datum der letzten Änderung: z. B. 07.07.2021; Entwicklungsstufe: Genehmigungsplanung; Koordinatensystem_Lage: Koordinatensystem_Lage: lokal; Lage_Status: ETRS89 / UTM zone 32N; Koordinatensystem_Höhe: DHHN2016; EPSG-Code_Koordinatensystem_Lage: -; EPSG-Code_Koordinatensystem_Höhe: 7837; Geotechnische Kategorie: GK3; Geotechnische Kategorie: Vorschrift: DIN 4020:2010-12; Erdbebenzone: 0; Erdbeben Baugrundklasse: C; Erdbeben Untergrundklasse: R; Erdbebengefährdung: Vorschrift: DIN EN 1998-1:2010-12 / DIN EN 1998-1/A1:2013-05; Höhensystem_Status: DHHN2016 / mNHN
Pset_rbfSBL_ProjectInformation - ProjectName: DGGT Beispiel; ProjectNumber: DGGT-Testprojekt-26-08-31-IFC-Varianten; Responsible: Geonova; Author: Geonova; Organization: Geonova; ModelAuthor: Geonova; DisciplineAuthor: Geonova; Description: DGGT-Testprojekt mit mehreren IFC-/Property-Set-Datensätzen für SVG/HTML und IFC4X3_ADD2.; ProjectPhase: Genehmigungsplanung; CreationDate: 2026-09-15; ModifiedDate: 2026-09-15; CoordinateReferenceSystem: lokal; ETRS89 / UTM zone 32N; EPSG-Code nicht angegeben; HeightReferenceSystem: DHHN2016 / mNHN / EPSG:7837; Notes: Projektphase: Genehmigungsplanung DGGT-Testprojekt: 15 einzelne BKF/CPT als IfcBorehole mit Erkundungsattributen und SVG-Zuordnung angereichert.

# IfcGeotechnicalStratum: Groundwater stratum, Grundwasserleiter Quartär
Description: Grundwasserleiter Quartär; PredefinedType: WATER
Pset_Grundwasser - Bezeichnung: Quartärwasserleiter; Auftretenswahrscheinlichkeit_T: 50; Fliessrichtung_von: SW; Fliessrichtung_nach: NO; Expositionsklasse Betonaggressivität: XA1; Betonaggressivität: Vorschrift: DIN 4030-1:2008-06; Bemessungsgrundwasserstand_charakteristisch_mittel: 18 m; Interpolationsverfahren_Messwasserstände: Radiale Basisfunktionen (RBF); Höhenbezug: DHHN2016 / mNHN / EPSG:7837; Schnittdarstellung: Messwasserstände: blaue Volllinie; Bemessungsgrundwasserstand: blaue gestrichelte Linie; Gemessene_Wasserstände_Anzahl: 10; Gemessener_Wasserstand_minimal: 17.64 m; Gemessener_Wasserstand_maximal: 18.9 m; Modellierte_Messwasserstandslinie: RBF-Interpolation aus gemessenen Wasserständen; Schichtbezug: S2
