Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Aufschluesse.ifc.tmp
Time: 2026-09-15T21:58:27+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, DGGT Beispiel – Vorgabe DGGT
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, DGGT Beispiel – Vorgabe DGGT
Description: Projektstandort; LongName: DGGT Beispiel – Vorgabe DGGT

# IfcBorehole: BKF (10)
Pset_rbfSBL_Erkundung - Erkundungsart: BKF; Aufschlussunterkante: -6.96 m; Quelle: Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx; Kommentar: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.; Bemessungsgrundwasserstand: 18 m
Pset_Bohrungen_gemäß_DIN_EN_ISO_22475_1_2007_01 - Aufschlussbezeichnung: BKF; Ausführende Firma: Schmidt & Schmidt Geotechnik; Gerätetyp: Klemm 806-3G; Geräteführer: Schmidt; Anmerkungen: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.
Pset_rbfSBL_Wasserstände - Bemessungswasserstand: 18 m
Pset_rbfSBL_BoreholeStratigraphy - Intervall_01_Kenner: S1; Intervall_01_Name: Auffüllung; Intervall_01_Offen_am_Erkundungsende: no; Intervall_02_Kenner: S2; Intervall_02_Name: Sand/Kies; Intervall_02_Offen_am_Erkundungsende: no; Intervall_03_Offen_am_Erkundungsende: no; Intervall_04_Offen_am_Erkundungsende: no
Name | Description | Erkundung | Stützstelle | Rechtswert (m) = Rechtswert Aufschluss (m) | Hochwert (m) = Hochwert Aufschluss (m) | Ansatzhöhe (m) = Höhe Ansatzpunkt_Aufschluss (m) = Intervall_01_Oberkante (m) | Aufschlusstiefe (m) | Bohrwasserstand_mNN (m) = Bohrwasserstand (m) | Aufschlussnummer | Aufschlussdatum_von = Aufschlussdatum_bis | Intervall_01_Unterkante (m) = Intervall_02_Oberkante (m) | Intervall_01_Mächtigkeit (m) | Intervall_01_Quelle = Intervall_02_Quelle = Intervall_03_Quelle = Intervall_04_Quelle | Intervall_02_Unterkante (m) = Intervall_03_Oberkante (m) | Intervall_02_Mächtigkeit (m) | Intervall_03_Kenner | Intervall_03_Name | Intervall_03_Unterkante (m) = Intervall_04_Oberkante (m) | Intervall_03_Mächtigkeit (m) | Intervall_04_Kenner | Intervall_04_Name | Intervall_04_Unterkante (m) | Intervall_04_Mächtigkeit (m)
BKF 1 | Einzelne geotechnische Erkundung BKF 1 | BKF 1 | ST_BKF_1 | 0.4 | 29.4 | 23.04 | 30 | 17.64 | 1 | 01.02.2021 | 20.54 | 2.5 | BKF 1; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.04 | 10.5 | S3 | Lösslehm | 0.74 | 9.3 | S4 | Sand- und Schluffstein | -6.96 | 7.7
BKF 10 | Einzelne geotechnische Erkundung BKF 10 | BKF 10 | ST_BKF_10 | 2.6 | 1.5 | 23.7 | 30.66 | 18.3 | 10 | 12.02.2021 | 20.94 | 2.76 | BKF 10; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.54 | 11.4 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) | 6.94 | 2.6 | S3 | Lösslehm | -2.41 | 9.35 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_05_Kenner: S4; Intervall_05_Name: Sand- und Schluffstein; Intervall_05_Oberkante: -2.41 m; Intervall_05_Unterkante: -6.96 m; Intervall_05_Mächtigkeit: 4.55 m; Intervall_05_Offen_am_Erkundungsende: no; Intervall_05_Quelle: BKF 10; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx
BKF 3 | Einzelne geotechnische Erkundung BKF 3 | BKF 3 | ST_BKF_3 | 54.1 | 58.4 | 25.7 | 32.66 | 18.9 | 3 | 03.02.2021 | 20.84 | 4.86 | BKF 3; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.04 | 10.8 | S3 | Lösslehm | 0.94 | 9.1 | S4 | Sand- und Schluffstein | -6.96 | 7.9
BKF 4 | Einzelne geotechnische Erkundung BKF 4 | BKF 4 | ST_BKF_4 | 99.2 | 59.3 | 28.16 | 35.12 | 18.56 | 4 | 04.02.2021 | 19.54 | 8.62 | BKF 4; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 7.14 | 12.4 | S3 | Lösslehm | -3.16 | 10.3 | S4 | Sand- und Schluffstein | -6.96 | 3.8
BKF 5 | Einzelne geotechnische Erkundung BKF 5 | BKF 5 | ST_BKF_5 | 89.7 | 30.8 | 23.4 | 30.36 | 18 | 5 | 05.02.2021 | 20.64 | 2.76 | BKF 5; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 11.04 | 9.6 | S3 | Lösslehm | 0.19 | 10.85 | S4 | Sand- und Schluffstein | -6.96 | 7.15
BKF 6 | Einzelne geotechnische Erkundung BKF 6 | BKF 6 | ST_BKF_6 | 99 | 0.7 | 23.14 | 30.1 | 18.64 | 6 | 08.02.2021 | 21.24 | 1.9 | BKF 6; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 11.84 | 9.4 | S3 | Lösslehm | 1.14 | 10.7 | S4 | Sand- und Schluffstein | -6.96 | 8.1
BKF 7 | Einzelne geotechnische Erkundung BKF 7 | BKF 7 | ST_BKF_7 | 48.4 | 26.6 | 23.06 | 30.02 | 18.76 | 7 | 09.02.2021 | 19.64 | 3.42 | BKF 7; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.24 | 10.4 | G1 | Schluff-Grenzlinse (auskeilende Zwischenschicht) | 7.14 | 2.1 | S3 | Lösslehm | -0.36 | 7.5 | Pset_rbfSBL_BoreholeStratigraphy - Intervall_05_Kenner: S4; Intervall_05_Name: Sand- und Schluffstein; Intervall_05_Oberkante: -0.36 m; Intervall_05_Unterkante: -6.96 m; Intervall_05_Mächtigkeit: 6.6 m; Intervall_05_Offen_am_Erkundungsende: no; Intervall_05_Quelle: BKF 7; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx
BKF 9 | Einzelne geotechnische Erkundung BKF 9 | BKF 9 | ST_BKF_9 | 25.4 | 15.8 | 23.08 | 30.04 | 17.98 | 9 | 11.02.2021 | 21.44 | 1.64 | BKF 9; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 11.24 | 10.2 | S3 | Lösslehm | 0.34 | 10.9 | S4 | Sand- und Schluffstein | -6.96 | 7.3
BKF/GW 2 | Einzelne geotechnische Erkundung BKF/GW 2 | BKF/GW 2 | ST_BKF_GW_2 | 8.9 | 58.6 | 22.94 | 29.9 | 18.04 | 2 | 02.02.2021 | 20.04 | 2.9 | BKF/GW 2; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.94 | 10.1 | S3 | Lösslehm | 1.24 | 8.7 | S4 | Sand- und Schluffstein | -6.96 | 8.2 | Pset_Bohrungen_gemäß_DIN_EN_ISO_22475_1_2007_01 - Zusatzbezeichnung: GW
BKF/GW 8 | Einzelne geotechnische Erkundung BKF/GW 8 | BKF/GW 8 | ST_BKF_GW_8 | 54.2 | 1.4 | 23.1 | 30.06 | 18.3 | 8 | 10.02.2021 | 20.84 | 2.26 | BKF/GW 8; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 7.44 | 13.4 | S3 | Lösslehm | -1.26 | 8.7 | S4 | Sand- und Schluffstein | -6.96 | 5.7 | Pset_Bohrungen_gemäß_DIN_EN_ISO_22475_1_2007_01 - Zusatzbezeichnung: GW

# IfcBorehole: CPT (5)
Pset_rbfSBL_Erkundung - Erkundungsart: CPT; Aufschlussunterkante: -6.96 m; Quelle: Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx; Kommentar: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.
Pset_Drucksondierung_gemäß_DIN_EN_ISO_22476_1_2013_10 - Aufschlussbezeichnung: CPT; Ausführende Firma: Schmidt & Schmidt Geotechnik; Typ der Drucksondierung: TE1; Anwendungsklasse: 2; Geräteführer: Schmidt; Anmerkungen: 1:1-Zuordnung im Beispiel; mehrere Erkundungen je Stützstelle sind möglich.
Pset_rbfSBL_BoreholeStratigraphy - Intervall_01_Kenner: S1; Intervall_01_Name: Auffüllung; Intervall_01_Offen_am_Erkundungsende: no; Intervall_02_Kenner: S2; Intervall_02_Name: Sand/Kies; Intervall_02_Offen_am_Erkundungsende: no; Intervall_03_Kenner: S3; Intervall_03_Name: Lösslehm; Intervall_03_Offen_am_Erkundungsende: no; Intervall_04_Kenner: S4; Intervall_04_Name: Sand- und Schluffstein; Intervall_04_Unterkante: -6.96 m; Intervall_04_Offen_am_Erkundungsende: no
Name | Description | Erkundung | Stützstelle | Rechtswert (m) = Rechtswert Aufschluss (m) | Hochwert (m) = Hochwert Aufschluss (m) | Ansatzhöhe (m) = Höhe Ansatzpunkt_Aufschluss (m) = Intervall_01_Oberkante (m) | Aufschlusstiefe (m) | Aufschlussnummer | Aufschlussdatum_von = Aufschlussdatum_bis | Intervall_01_Unterkante (m) = Intervall_02_Oberkante (m) | Intervall_01_Mächtigkeit (m) | Intervall_01_Quelle = Intervall_02_Quelle = Intervall_03_Quelle = Intervall_04_Quelle | Intervall_02_Unterkante (m) = Intervall_03_Oberkante (m) | Intervall_02_Mächtigkeit (m) | Intervall_03_Unterkante (m) = Intervall_04_Oberkante (m) | Intervall_03_Mächtigkeit (m) | Intervall_04_Mächtigkeit (m)
CPT 1 | Einzelne geotechnische Erkundung CPT 1 | CPT 1 | ST_CPT_1 | 9.3 | 58.1 | 22.95 | 29.91 | 1 | 25.01.2021 | 19.94 | 3.01 | CPT 1; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.04 | 9.9 | 1.14 | 8.9 | 8.1
CPT 2 | Einzelne geotechnische Erkundung CPT 2 | CPT 2 | ST_CPT_2 | 55.1 | 58.3 | 25.9 | 32.86 | 2 | 26.01.2021 | 20.74 | 5.16 | CPT 2; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 10.14 | 10.6 | 0.74 | 9.4 | 7.7
CPT 3 | Einzelne geotechnische Erkundung CPT 3 | CPT 3 | ST_CPT_3 | 69.4 | 43.8 | 24.1 | 31.06 | 3 | 27.01.2021 | 20.44 | 3.66 | CPT 3; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.34 | 11.1 | -2.16 | 11.5 | 4.8
CPT 4 | Einzelne geotechnische Erkundung CPT 4 | CPT 4 | ST_CPT_4 | 77.8 | 15.3 | 23.12 | 30.08 | 4 | 28.01.2021 | 20.94 | 2.18 | CPT 4; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.94 | 11 | 1.34 | 8.6 | 8.3
CPT 5 | Einzelne geotechnische Erkundung CPT 5 | CPT 5 | ST_CPT_5 | 26.5 | 44.5 | 23.01 | 29.97 | 5 | 29.01.2021 | 20.74 | 2.27 | CPT 5; Testprojekt-Lage Bohrungen und CPT.xlsx; Testprojekt-Baugrundschichten an den Aufschlüssen.xlsx | 9.24 | 11.5 | -0.06 | 9.3 | 6.9

# IfcGeomodel: rbfSBL IfcGeomodel, DGGT Beispiel – Vorgabe DGGT – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_Allgemeine_Projektinformationen - Projektname: Testprojekt-Fachmodell_Baugrund; Modellautor: z. B. Jörg Bauer; Fachautor: z. B. Jörg Bauer; Datum der Erstellung: z. B. 24.06.2021; Datum der letzten Änderung: z. B. 07.07.2021; Entwicklungsstufe: Genehmigungsplanung; Koordinatensystem_Lage: Koordinatensystem_Lage: lokal; Lage_Status: ETRS89 / UTM zone 32N; Koordinatensystem_Höhe: DHHN2016; EPSG-Code_Koordinatensystem_Lage: -; EPSG-Code_Koordinatensystem_Höhe: 7837; Geotechnische Kategorie: GK3; Geotechnische Kategorie: Vorschrift: DIN 4020:2010-12; Erdbebenzone: 0; Erdbeben Baugrundklasse: C; Erdbeben Untergrundklasse: R; Erdbebengefährdung: Vorschrift: DIN EN 1998-1:2010-12 / DIN EN 1998-1/A1:2013-05; Höhensystem_Status: DHHN2016 / mNHN
Pset_rbfSBL_ProjectInformation - ProjectName: DGGT Beispiel; ProjectNumber: DGGT-Testprojekt-26-08-31-IFC-Varianten; Responsible: Geonova; Author: Geonova; Organization: Geonova; ModelAuthor: Geonova; DisciplineAuthor: Geonova; Description: DGGT-Testprojekt mit mehreren IFC-/Property-Set-Datensätzen für SVG/HTML und IFC4X3_ADD2.; ProjectPhase: Genehmigungsplanung; CreationDate: 2026-09-15; ModifiedDate: 2026-09-15; CoordinateReferenceSystem: lokal; ETRS89 / UTM zone 32N; EPSG-Code nicht angegeben; HeightReferenceSystem: DHHN2016 / mNHN / EPSG:7837; Notes: Projektphase: Genehmigungsplanung DGGT-Testprojekt: 15 einzelne BKF/CPT als IfcBorehole mit Erkundungsattributen und SVG-Zuordnung angereichert.
